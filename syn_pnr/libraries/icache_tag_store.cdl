*
* Copyright 2022 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
* Generated by bif2cdl v3.4.15
* Version: r0p0-00eac0
* Name: sram_sp_hdc_svt_rvt_hvt Compiler|TSMC cln65gplus 65nm Process, 0.525um2 Bitcell
* Comment:
* Configuration:  -instname "icache_tag_store" -words 512 -bits 21 \
* Configuration: -frequency 50 -mux 4 -pipeline off -write_mask on \
* Configuration: -wp_size 1 -write_thru on -top_layer "m5-m9" -powe\
* Configuration: r_type otc -redundancy off -rcols 2 -rrows 2 -bmux\
* Configuration:  off -ser none -back_biasing off -power_gating off\
* Configuration:  -retention on -ema on -atf off -cust_comment "" -\
* Configuration: bus_notation on -left_bus_delim "[" -right_bus_del\
* Configuration: im "]" -pwr_gnd_rename "VDDPE:VDDPE,VDDCE:VDDCE,VS\
* Configuration: SE:VSSE" -prefix "" -name_case upper -check_instna\
* Configuration: me off -diodes on -drive 6 -dnw off -asvm on -corn\
* Configuration: ers ss_0p90v_0p90v_125c,ss_0p90v_0p90v_m40c,ff_1p1\
* Configuration: 0v_1p10v_m40c,ff_1p10v_1p10v_125c,ff_1p10v_1p10v_0\
* Configuration: c,tt_1p00v_1p00v_25c
* Codefile:
*
*
** begin lvs.header
** $Revision: 1.1 $
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT icache_tag_storeFPIO4 BWEI BWEN CREN D DNI Q Q_ RET RETN_TERM TIEHIGH
+  TIELOW VSSE VDDPE VDDCE
** icache_tag_storeFPIO4: 11 flat devices **
D10 VSSE Q NDIO 1.024e-07U 1.28U $name=/D4
D7 VSSE BWEN NDIO 1.024e-07U 1.28U $name=/D7
D8 VSSE D NDIO 1.024e-07U 1.28U $name=/D6
D9 VSSE CREN NDIO 1.024e-07U 1.28U $name=/D5
M0 Q Q_ VSSE VSSE NCH W=2.8U L=0.06U M=1 $name=/qdrv/N00
M1 VDDPE Q_ Q VDDCE PCH W=4.14U L=0.06U M=1 $name=/qdrv/P00
M2 Q RET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N15/N00
M3 DNI D VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I238/N00
M4 VDDPE D DNI VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I238/P00
M5 BWEI BWEN VSSE VSSE NCH_HVT W=0.25U L=0.06U M=1 $name=/I237/N00
M6 VDDPE BWEN BWEI VDDCE PCH_HVT W=0.5U L=0.06U M=1 $name=/I237/P00
.ENDS icache_tag_storeFPIO4
****
.SUBCKT icache_tag_storeFPIO8RR11B1 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5
+  BWEI_6 BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEN_0 BWEN_1 BWEN_2 BWEN_3 BWEN_4
+  BWEN_5 BWEN_6 BWEN_7 BWEN_8 BWEN_9 BWEN_10 CREN DNI_0 DNI_1 DNI_2 DNI_3
+  DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9 DNI_10 D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7
+  D_8 D_9 D_10 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q__0 Q__1 Q__2
+  Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9 Q__10 RETN_TERM_0 RETN_TERM_1
+  RETN_TERM_2 RETN_TERM_3 RETN_TERM_4 RETN_TERM_5 RETN_TERM_6 RETN_TERM_7
+  RETN_TERM_8 RETN_TERM_9 RETN_TERM_10 RET_0 RET_1 RET_2 RET_3 RET_4 RET_5
+  RET_6 RET_7 RET_8 RET_9 RET_10 TIELOW VSSE VDDPE VDDCE
** icache_tag_storeFPIO8RR11B1: 121 flat devices **
XRIGHTIO0 BWEI_0 BWEN_0 CREN D_0 DNI_0 Q_0 Q__0 RET_0 RETN_TERM_0 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XRIGHTIO1 BWEI_1 BWEN_1 CREN D_1 DNI_1 Q_1 Q__1 RET_1 RETN_TERM_1 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XRIGHTIO2 BWEI_2 BWEN_2 CREN D_2 DNI_2 Q_2 Q__2 RET_2 RETN_TERM_2 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XRIGHTIO3 BWEI_3 BWEN_3 CREN D_3 DNI_3 Q_3 Q__3 RET_3 RETN_TERM_3 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XRIGHTIO4 BWEI_4 BWEN_4 CREN D_4 DNI_4 Q_4 Q__4 RET_4 RETN_TERM_4 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XRIGHTIO5 BWEI_5 BWEN_5 CREN D_5 DNI_5 Q_5 Q__5 RET_5 RETN_TERM_5 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XRIGHTIO6 BWEI_6 BWEN_6 CREN D_6 DNI_6 Q_6 Q__6 RET_6 RETN_TERM_6 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XRIGHTIO7 BWEI_7 BWEN_7 CREN D_7 DNI_7 Q_7 Q__7 RET_7 RETN_TERM_7 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XRIGHTIO8 BWEI_8 BWEN_8 CREN D_8 DNI_8 Q_8 Q__8 RET_8 RETN_TERM_8 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XRIGHTIO9 BWEI_9 BWEN_9 CREN D_9 DNI_9 Q_9 Q__9 RET_9 RETN_TERM_9 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XRIGHTIOEXT10 BWEI_10 BWEN_10 CREN D_10 DNI_10 Q_10 Q__10 RET_10 RETN_TERM_10
+  CREN TIELOW VSSE VDDPE VDDCE icache_tag_storeFPIO4
.ENDS icache_tag_storeFPIO8RR11B1
****
.SUBCKT icache_tag_storeFPAL4_CTRL AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4
+  AI4N AI5 AI5N AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11 AI11N
+  AI12 AI12N AI13 AI13N BWEN CEI CEN CLK EMA0 EMA1 EMA2 IRET IRETN RDT RETN
+  STOV TIEHIGH TIELOW WBT WEI WEN VSSE VDDPE VDDCE
** icache_tag_storeFPAL4_CTRL: 54 flat devices **
D10 VSSE CLK NDIO 1.024e-07U 1.28U $name=/I2449/D1
D11 VSSE CEN NDIO 1.024e-07U 1.28U $name=/I2449/D0
D4 VSSE STOV NDIO 1.024e-07U 1.28U $name=/I2449/D7
D40 VSSE AI5 NDIO 1.024e-07U 1.28U $name=/I2450/D9
D41 VSSE AI4 NDIO 1.024e-07U 1.28U $name=/I2450/D8
D42 VSSE AI6 NDIO 1.024e-07U 1.28U $name=/I2450/D7
D43 VSSE AI7 NDIO 1.024e-07U 1.28U $name=/I2450/D6
D44 VSSE AI9 NDIO 1.024e-07U 1.28U $name=/I2450/D5
D45 VSSE AI8 NDIO 1.024e-07U 1.28U $name=/I2450/D4
D46 VSSE AI10 NDIO 1.024e-07U 1.28U $name=/I2450/D3
D47 VSSE AI11 NDIO 1.024e-07U 1.28U $name=/I2450/D2
D48 VSSE AI1 NDIO 1.024e-07U 1.28U $name=/I2450/D13
D49 VSSE AI0 NDIO 1.024e-07U 1.28U $name=/I2450/D12
D5 VSSE EMA0 NDIO 1.024e-07U 1.28U $name=/I2449/D6
D50 VSSE AI2 NDIO 1.024e-07U 1.28U $name=/I2450/D11
D51 VSSE AI3 NDIO 1.024e-07U 1.28U $name=/I2450/D10
D52 VSSE AI12 NDIO 1.024e-07U 1.28U $name=/I2450/D1
D53 VSSE AI13 NDIO 1.024e-07U 1.28U $name=/I2450/D0
D6 VSSE RETN NDIO 1.024e-07U 1.28U $name=/I2449/D3
D7 VSSE WEN NDIO 1.024e-07U 1.28U $name=/I2449/D2
D8 VSSE WBT NDIO 1.024e-07U 1.28U $name=/I2449/D12
D9 VSSE RDT NDIO 1.024e-07U 1.28U $name=/I2449/D11
M0 WEI WEN VSSE VSSE NCH W=1.68U L=0.06U M=1 $name=/I2449/tnorwece/N00
M1 VDDPE WEN WEI VDDCE PCH W=2.3U L=0.06U M=1 $name=/I2449/tnorwece/P00
M12 AI7N AI7 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I9/N00
M13 VDDPE AI7 AI7N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I9/P00
M14 AI6N AI6 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I8/N00
M15 VDDPE AI6 AI6N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I8/P00
M16 AI5N AI5 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I7/N00
M17 VDDPE AI5 AI5N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I7/P00
M18 AI0N AI0 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I60/N00
M19 VDDPE AI0 AI0N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I60/P00
M2 CEI CEN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I2449/tceninv/N00
M20 AI2N AI2 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I4/N00
M21 VDDPE AI2 AI2N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I4/P00
M22 AI1N AI1 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I3/N00
M23 VDDPE AI1 AI1N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I3/P00
M24 AI13N AI13 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I15/N00
M25 VDDPE AI13 AI13N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I15/P00
M26 AI12N AI12 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I14/N00
M27 VDDPE AI12 AI12N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I14/P00
M28 AI11N AI11 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I13/N00
M29 VDDPE AI11 AI11N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I13/P00
M3 VDDPE CEN CEI VDDCE PCH W=0.15U L=0.06U M=1 $name=/I2449/tceninv/P00
M30 AI10N AI10 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I12/N00
M31 VDDPE AI10 AI10N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I12/P00
M32 AI9N AI9 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I11/N00
M33 VDDPE AI9 AI9N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I11/P00
M34 AI8N AI8 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I10/N00
M35 VDDPE AI8 AI8N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I10/P00
M36 AI3N AI3 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I1/N00
M37 VDDPE AI3 AI3N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I1/P00
M38 AI4N AI4 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I0/N00
M39 VDDPE AI4 AI4N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I0/P00
.ENDS icache_tag_storeFPAL4_CTRL
****
.SUBCKT icache_tag_storeFPBCTRL21M4 AI0 AI0N AI1 AI1N AI2N AI3N AI4N AI5 AI5N
+  AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11 AI11N AI12N AI13N CEI
+  CEN CLK EMA0 EMA1 EMA2 IRET IRETN RETN TIEHIGH TIELOW WEI WEN VSSE VDDPE
+  VDDCE
** icache_tag_storeFPBCTRL21M4: 54 flat devices **
XINSTCTRL AI0 AI0N AI1 AI1N TIELOW AI2N TIELOW AI3N TIELOW AI4N AI5 AI5N AI6
+  AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11 AI11N TIELOW AI12N TIELOW
+  AI13N TIELOW CEI CEN CLK EMA0 EMA1 EMA2 IRET IRETN TIELOW RETN TIELOW
+  TIEHIGH TIELOW TIELOW WEI WEN VSSE VDDPE VDDCE icache_tag_storeFPAL4_CTRL
.ENDS icache_tag_storeFPBCTRL21M4
****
.SUBCKT icache_tag_storeFPIO8RL10B1 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5
+  BWEI_6 BWEI_7 BWEI_8 BWEI_9 BWEN_0 BWEN_1 BWEN_2 BWEN_3 BWEN_4 BWEN_5
+  BWEN_6 BWEN_7 BWEN_8 BWEN_9 CREN DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6
+  DNI_7 DNI_8 DNI_9 D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 Q_0 Q_1 Q_2 Q_3
+  Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9
+  RETN_TERM_0 RETN_TERM_1 RETN_TERM_2 RETN_TERM_3 RETN_TERM_4 RETN_TERM_5
+  RETN_TERM_6 RETN_TERM_7 RETN_TERM_8 RETN_TERM_9 RET_0 RET_1 RET_2 RET_3
+  RET_4 RET_5 RET_6 RET_7 RET_8 RET_9 TIELOW VSSE VDDPE VDDCE
** icache_tag_storeFPIO8RL10B1: 110 flat devices **
XLEFTIO0 BWEI_0 BWEN_0 CREN D_0 DNI_0 Q_0 Q__0 RET_0 RETN_TERM_0 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XLEFTIO1 BWEI_1 BWEN_1 CREN D_1 DNI_1 Q_1 Q__1 RET_1 RETN_TERM_1 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XLEFTIO2 BWEI_2 BWEN_2 CREN D_2 DNI_2 Q_2 Q__2 RET_2 RETN_TERM_2 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XLEFTIO3 BWEI_3 BWEN_3 CREN D_3 DNI_3 Q_3 Q__3 RET_3 RETN_TERM_3 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XLEFTIO4 BWEI_4 BWEN_4 CREN D_4 DNI_4 Q_4 Q__4 RET_4 RETN_TERM_4 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XLEFTIO5 BWEI_5 BWEN_5 CREN D_5 DNI_5 Q_5 Q__5 RET_5 RETN_TERM_5 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XLEFTIO6 BWEI_6 BWEN_6 CREN D_6 DNI_6 Q_6 Q__6 RET_6 RETN_TERM_6 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XLEFTIO7 BWEI_7 BWEN_7 CREN D_7 DNI_7 Q_7 Q__7 RET_7 RETN_TERM_7 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XLEFTIO8 BWEI_8 BWEN_8 CREN D_8 DNI_8 Q_8 Q__8 RET_8 RETN_TERM_8 CREN TIELOW
+  VSSE VDDPE VDDCE icache_tag_storeFPIO4
XLEFTIOEXT9 BWEI_9 BWEN_9 CREN D_9 DNI_9 Q_9 Q__9 RET_9 RETN_TERM_9 CREN
+  TIELOW VSSE VDDPE VDDCE icache_tag_storeFPIO4
.ENDS icache_tag_storeFPIO8RL10B1
****
.SUBCKT icache_tag_storeBR21FPIO8B1 AI0 AI0N AI1 AI1N AI2N AI3N AI4N AI5 AI5N
+  AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11 AI11N AI12N AI13N
+  BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5 BWEI_6 BWEI_7 BWEI_8 BWEI_9
+  BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15 BWEI_16 BWEI_17 BWEI_18
+  BWEI_19 BWEI_20 BWEN_0 BWEN_1 BWEN_2 BWEN_3 BWEN_4 BWEN_5 BWEN_6 BWEN_7
+  BWEN_8 BWEN_9 BWEN_10 BWEN_11 BWEN_12 BWEN_13 BWEN_14 BWEN_15 BWEN_16
+  BWEN_17 BWEN_18 BWEN_19 BWEN_20 CEI CEN CLK CREN DNI_0 DNI_1 DNI_2 DNI_3
+  DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9 DNI_10 DNI_11 DNI_12 DNI_13 DNI_14
+  DNI_15 DNI_16 DNI_17 DNI_18 DNI_19 DNI_20 D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7
+  D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 D_16 D_17 D_18 D_19 D_20 EMA0 EMA1
+  EMA2 IRET IRETN Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13
+  Q_14 Q_15 Q_16 Q_17 Q_18 Q_19 Q_20 Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7
+  Q__8 Q__9 Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 Q__16 Q__17 Q__18 Q__19 Q__20
+  RETN RETN_TERM_0 RETN_TERM_1 RETN_TERM_2 RETN_TERM_3 RETN_TERM_4
+  RETN_TERM_5 RETN_TERM_6 RETN_TERM_7 RETN_TERM_8 RETN_TERM_9 RETN_TERM_10
+  RETN_TERM_11 RETN_TERM_12 RETN_TERM_13 RETN_TERM_14 RETN_TERM_15
+  RETN_TERM_16 RETN_TERM_17 RETN_TERM_18 RETN_TERM_19 RETN_TERM_20 RET_0
+  RET_1 RET_2 RET_3 RET_4 RET_5 RET_6 RET_7 RET_8 RET_9 RET_10 RET_11 RET_12
+  RET_13 RET_14 RET_15 RET_16 RET_17 RET_18 RET_19 RET_20 TIELOW WEI WEN VSSE
+  VDDPE VDDCE
** icache_tag_storeBR21FPIO8B1: 285 flat devices **
XBOTCTRL AI0 AI0N AI1 AI1N AI2N AI3N AI4N AI5 AI5N AI6 AI6N AI7 AI7N AI8 AI8N
+  AI9 AI9N AI10 AI10N AI11 AI11N AI12N AI13N CEI CEN CLK EMA0 EMA1 EMA2 IRET
+  IRETN RETN CREN TIELOW WEI WEN VSSE VDDPE VDDCE icache_tag_storeFPBCTRL21M4
XLEFTIOROW BWEI_9 BWEI_8 BWEI_7 BWEI_6 BWEI_5 BWEI_4 BWEI_3 BWEI_2 BWEI_1
+  BWEI_0 BWEN_9 BWEN_8 BWEN_7 BWEN_6 BWEN_5 BWEN_4 BWEN_3 BWEN_2 BWEN_1
+  BWEN_0 CREN DNI_9 DNI_8 DNI_7 DNI_6 DNI_5 DNI_4 DNI_3 DNI_2 DNI_1 DNI_0 D_9
+  D_8 D_7 D_6 D_5 D_4 D_3 D_2 D_1 D_0 Q_9 Q_8 Q_7 Q_6 Q_5 Q_4 Q_3 Q_2 Q_1 Q_0
+  Q__9 Q__8 Q__7 Q__6 Q__5 Q__4 Q__3 Q__2 Q__1 Q__0 RETN_TERM_9 RETN_TERM_8
+  RETN_TERM_7 RETN_TERM_6 RETN_TERM_5 RETN_TERM_4 RETN_TERM_3 RETN_TERM_2
+  RETN_TERM_1 RETN_TERM_0 RET_9 RET_8 RET_7 RET_6 RET_5 RET_4 RET_3 RET_2
+  RET_1 RET_0 TIELOW VSSE VDDPE VDDCE icache_tag_storeFPIO8RL10B1
XRIGHTIOROW BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15 BWEI_16 BWEI_17
+  BWEI_18 BWEI_19 BWEI_20 BWEN_10 BWEN_11 BWEN_12 BWEN_13 BWEN_14 BWEN_15
+  BWEN_16 BWEN_17 BWEN_18 BWEN_19 BWEN_20 CREN DNI_10 DNI_11 DNI_12 DNI_13
+  DNI_14 DNI_15 DNI_16 DNI_17 DNI_18 DNI_19 DNI_20 D_10 D_11 D_12 D_13 D_14
+  D_15 D_16 D_17 D_18 D_19 D_20 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 Q_16 Q_17 Q_18
+  Q_19 Q_20 Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 Q__16 Q__17 Q__18 Q__19 Q__20
+  RETN_TERM_10 RETN_TERM_11 RETN_TERM_12 RETN_TERM_13 RETN_TERM_14
+  RETN_TERM_15 RETN_TERM_16 RETN_TERM_17 RETN_TERM_18 RETN_TERM_19
+  RETN_TERM_20 RET_10 RET_11 RET_12 RET_13 RET_14 RET_15 RET_16 RET_17 RET_18
+  RET_19 RET_20 TIELOW VSSE VDDPE VDDCE icache_tag_storeFPIO8RR11B1
.ENDS icache_tag_storeBR21FPIO8B1
****
.SUBCKT icache_tag_storeIO4 BLTERM0 BLTERM0_ BLTERM1 BLTERM1_ BLTERM2 BLTERM2_
+  BLTERM3 BLTERM3_ BWEI CE_WE CREN CRENA CRENB CRENI DNI FIOGTP GDL GDLA
+  GDLA_ GDLB GDLB_ GDLI GDLI_ GDL_ IODL IODL_ IOGTP IRET IRETN Q_ RDEN
+  TIEHIGH TIELOW WE WEA WEB WEI YI YP1_0 YP1_1 YP1_2 YP1_3 YSN YSNA YSNB YSNI
+  VSSE VDDPE VDDCE
** icache_tag_storeIO4: 178 flat devices **
M0 HNET125 NET362 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gpreg/N11
M1 NET345 YSEL HNET125 VSSE NCH W=0.5U L=0.06U M=1 $name=/gpreg/N10
M10 VDDPE NET364 NET348 VDDCE PCH W=1U L=0.06U M=1 $name=/gpnand/P10
M100 NET518 NET408 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/tgdlpdkp/N00
M101 IODW_ WE NET518 VSSE NCH W=1.5U L=0.06U M=1 $name=/tgdlnpgn/N00
M102 VSSE NET518 IODL VSSE NCH W=3U L=0.06U M=1 $name=/tgdldrvn/N00
M103 NET384 NET364 WEI VSSE NCH W=1U L=0.06U M=1 $name=/N9/N00
M104 NET550 NET408 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/N43/N00
M105 NET384 NET362 WE VSSE NCH W=1U L=0.06U M=1 $name=/N4/N00
M106 VSSE NET550 IODL_ VSSE NCH W=3U L=0.06U M=1 $name=/N38/N00
M107 GDL NET537 IODL VSSE NCH W=3U L=0.06U M=1 $name=/N3/N00
M108 IODL NET540 GDLI VSSE NCH W=3U L=0.06U M=1 $name=/N2/N00
M109 NET545 QIE_N VSSE VSSE NCH W=1.08U L=0.06U M=1 $name=/N17/N00
M11 VDDPE YSEL NET348 VDDCE PCH W=1U L=0.06U M=1 $name=/gpnand/P00
M110 IODW WE NET547 VSSE NCH W=1.5U L=0.06U M=1 $name=/N12/N00
M111 IODW WE NET550 VSSE NCH W=1.5U L=0.06U M=1 $name=/N11/N00
M112 IODL_ NET537 GDL_ VSSE NCH W=3U L=0.06U M=1 $name=/N10/N00
M113 IODL_ NET540 GDLI_ VSSE NCH W=3U L=0.06U M=1 $name=/N0/N00
M114 HNET371 CREN VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I244/N01
M115 NET559 CRENI HNET371 VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I244/N00
M116 VDDPE CREN NET559 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I244/P10
M117 VDDPE CRENI NET559 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I244/P00
M118 YILOUT NET351 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I3/N00
M119 VDDPE NET351 YILOUT VDDCE PCH W=0.3U L=0.06U M=1 $name=/I3/P00
M12 NET575 NET339 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/tiginvpredrv/N10
M120 NET563 YI VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I1/N00
M121 VDDPE YI NET563 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I1/P00
M122 WE WELOUTN VSSE VSSE NCH W=2U L=0.06U M=1 $name=/weidrv/N00
M123 VDDPE WELOUTN WE VDDCE PCH W=4U L=0.06U M=1 $name=/weidrv/P00
M124 NET567 BWEI VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/tweinv/N00
M125 VDDPE BWEI NET567 VDDCE PCH W=0.33U L=0.06U M=1 $name=/tweinv/P00
M126 NET569 IODL_ VSSE VSSE NCH W=0.36U L=0.06U M=1 $name=/tqbpu2drv/N00
M127 VDDPE IODL_ NET569 VDDCE PCH W=0.7U L=0.06U M=1 $name=/tqbpu2drv/P00
M128 QILAT Q_ VSSE VSSE NCH W=0.24U L=0.06U M=1 $name=/tqbfbinv/N00
M129 VDDPE Q_ QILAT VDDCE PCH W=0.47U L=0.06U M=1 $name=/tqbfbinv/P00
M13 NET575 RDEN VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/tiginvpredrv/N00
M130 QIE_N QIE_P VSSE VSSE NCH W=0.36U L=0.06U M=1 $name=/tlinv/N00
M131 VDDPE QIE_P QIE_N VDDCE PCH W=0.49U L=0.06U M=1 $name=/tlinv/P00
M132 QIE_P NET575 VSSE VSSE NCH W=0.62U L=0.06U M=1 $name=/tiginv/N00
M133 VDDPE NET575 QIE_P VDDCE PCH W=1.2U L=0.06U M=1 $name=/tiginv/P00
M134 NET579 IOGTPD VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/tgtpn/N00
M135 VDDPE IOGTPD NET579 VDDCE PCH W=0.56U L=0.06U M=1 $name=/tgtpn/P00
M136 NET581 NET619 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/tdinv/N00
M137 VDDPE NET619 NET581 VDDCE PCH W=0.33U L=0.06U M=1 $name=/tdinv/P00
M138 NET583 DNI VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/tdininv/N00
M139 VDDPE DNI NET583 VDDCE PCH W=0.33U L=0.06U M=1 $name=/tdininv/P00
M14 VDDPE NET339 HNET133 VDDCE PCH W=0.4U L=0.06U M=1 $name=/tiginvpredrv/P01
M140 YSEL YSN VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/gyselinv/N00
M141 VDDPE YSN YSEL VDDCE PCH W=0.6U L=0.06U M=1 $name=/gyselinv/P00
M142 WELOUTN WELOUT VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gwelat/N00
M143 VDDPE WELOUT WELOUTN VDDCE PCH W=1.4U L=0.06U M=1 $name=/gwelat/P00
M144 WEIN NET330 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gwdly/N00
M145 VDDPE NET330 WEIN VDDCE PCH W=0.82U L=0.06U M=1 $name=/gwdly/P00
M146 NET591 IOGTP VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gtp/N00
M147 VDDPE IOGTP NET591 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gtp/P00
M148 NET540 NET348 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gpginv/N00
M149 VDDPE NET348 NET540 VDDCE PCH W=1U L=0.06U M=1 $name=/gpginv/P00
M15 HNET133 RDEN NET575 VDDCE PCH W=0.4U L=0.06U M=1 $name=/tiginvpredrv/P00
M150 YSN YILOUT VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gpgdrv2/N00
M151 VDDPE YILOUT YSN VDDCE PCH W=1U L=0.06U M=1 $name=/gpgdrv2/P00
M152 NET597 NET509 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gpgdrv1/N00
M153 VDDPE NET509 NET597 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gpgdrv1/P00
M154 NET537 NET345 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gnreg/N00
M155 VDDPE NET345 NET537 VDDCE PCH W=1U L=0.06U M=1 $name=/gnreg/P00
M156 NET408 WE VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/geninv/N00
M157 VDDPE WE NET408 VDDCE PCH W=2.7U L=0.06U M=1 $name=/geninv/P00
M158 IODW DLOUTN VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gdndrv/N00
M159 VDDPE DLOUTN IODW VDDCE PCH W=2U L=0.06U M=1 $name=/gdndrv/P00
M16 HNET139 NET617 VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/wnand/N01
M160 DLOUTN DLOUT VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/gdlat/N00
M161 VDDPE DLOUT DLOUTN VDDCE PCH W=1.98U L=0.06U M=1 $name=/gdlat/P00
M162 NET607 DLOUTN VSSE VSSE NCH W=0.58U L=0.06U M=1 $name=/gddrvb/N00
M163 VDDPE DLOUTN NET607 VDDCE PCH W=1.14U L=0.06U M=1 $name=/gddrvb/P00
M164 IODW_ NET607 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gddrv/N00
M165 VDDPE NET607 IODW_ VDDCE PCH W=2U L=0.06U M=1 $name=/gddrv/P00
M166 DIN NET613 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gddly2/N00
M167 VDDPE NET613 DIN VDDCE PCH W=1U L=0.06U M=1 $name=/gddly2/P00
M168 NET613 NET581 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/gddly/N00
M169 VDDPE NET581 NET613 VDDCE PCH W=0.33U L=0.06U M=1 $name=/gddly/P00
M17 NET330 CE_WE HNET139 VSSE NCH W=0.25U L=0.06U M=1 $name=/wnand/N00
M170 NET364 NET362 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gcrendd/N00
M171 VDDPE NET362 NET364 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gcrendd/P00
M172 NET615 FIOGTP VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I34/N00
M173 VDDPE FIOGTP NET615 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I34/P00
M174 NET617 NET567 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/I12/N00
M175 VDDPE NET567 NET617 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I12/P00
M176 NET619 NET583 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/I10/N00
M177 VDDPE NET583 NET619 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I10/P00
M18 VDDPE NET617 NET330 VDDCE PCH W=0.25U L=0.06U M=1 $name=/wnand/P10
M19 VDDPE CE_WE NET330 VDDCE PCH W=0.25U L=0.06U M=1 $name=/wnand/P00
M2 HNET122 NET362 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gpreg/N01
M20 HNET143 NET615 VSSE VSSE NCH W=0.84U L=0.06U M=1 $name=/tiogdlprech/N01
M21 NET477 IOGTPD HNET143 VSSE NCH W=0.84U L=0.06U M=1 $name=/tiogdlprech/N00
M22 VDDPE NET615 NET477 VDDCE PCH W=0.83U L=0.06U M=1 $name=/tiogdlprech/P10
M23 VDDPE IOGTPD NET477 VDDCE PCH W=0.83U L=0.06U M=1 $name=/tiogdlprech/P00
M24 HNET147 NET591 VSSE VSSE NCH W=0.75U L=0.06U M=1 $name=/tgtpnd2/N01
M25 IOGTPD QIE_P HNET147 VSSE NCH W=0.75U L=0.06U M=1 $name=/tgtpnd2/N00
M26 VDDPE NET591 IOGTPD VDDCE PCH W=0.74U L=0.06U M=1 $name=/tgtpnd2/P10
M27 VDDPE QIE_P IOGTPD VDDCE PCH W=0.74U L=0.06U M=1 $name=/tgtpnd2/P00
M28 HNET151 IOGTP VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tfiogtpnd2/N01
M29 NET339 NET615 HNET151 VSSE NCH W=0.15U L=0.06U M=1 $name=/tfiogtpnd2/N00
M3 NET345 YSEL HNET122 VSSE NCH W=0.5U L=0.06U M=1 $name=/gpreg/N00
M30 VDDPE IOGTP NET339 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tfiogtpnd2/P10
M31 VDDPE NET615 NET339 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tfiogtpnd2/P00
M32 HNET155 NET384 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gweio/N01
M33 NET342 NET597 HNET155 VSSE NCH W=1U L=0.06U M=1 $name=/gweio/N00
M34 VDDPE NET384 NET342 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gweio/P10
M35 VDDPE NET597 NET342 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gweio/P00
M36 HNET162 YILOUT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I2/NI00
M37 NET351 IOGTPD HNET162 VSSE NCH W=0.15U L=0.06U M=1 $name=/I2/NE00
M38 HNET157 NET579 NET351 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I2/PE00
M39 VDDPE YILOUT HNET157 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I2/PI00
M4 VDDPE NET362 NET345 VDDCE PCH W=1U L=0.06U M=1 $name=/gpreg/P10
M40 HNET168 WELOUTN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gwelatfb/NI00
M41 WELOUT IOGTPD HNET168 VSSE NCH W=0.15U L=0.06U M=1 $name=/gwelatfb/NE00
M42 HNET163 NET579 WELOUT VDDCE PCH W=0.15U L=0.06U M=1 $name=/gwelatfb/PE00
M43 VDDPE WELOUTN HNET163 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gwelatfb/PI00
M44 HNET174 DLOUTN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gdlatfb/NI00
M45 DLOUT IOGTPD HNET174 VSSE NCH W=0.15U L=0.06U M=1 $name=/gdlatfb/NE00
M46 HNET169 NET579 DLOUT VDDCE PCH W=0.15U L=0.06U M=1 $name=/gdlatfb/PE00
M47 VDDPE DLOUTN HNET169 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gdlatfb/PI00
M48 NET362 NET559 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/tcrend/N00
M49 VDDPE NET559 NET362 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/tcrend/P00
M5 VDDPE YSEL NET345 VDDCE PCH W=1U L=0.06U M=1 $name=/gpreg/P00
M50 Q_ IRETN VDDPE VDDCE PCH_HVT W=1.06U L=0.06U M=1 $name=/tqbpuretn/P00
M51 NET373 QILAT Q_ VDDCE PCH_HVT W=1.06U L=0.06U M=1 $name=/tqbpu2/P00
M52 VDDPE QIE_N NET373 VDDCE PCH_HVT W=1.06U L=0.06U M=1 $name=/P35/P00
M53 VDDPE NET569 NET373 VDDCE PCH_HVT W=1.06U L=0.06U M=1 $name=/P33/P00
M54 WELOUT IOGTPD WEIN VDDCE PCH W=0.49U L=0.06U M=1 $name=/wpgp/P00
M55 NET383 IODL Q_ VDDCE PCH W=2.13U L=0.06U M=1 $name=/tqbpu/P00
M56 VDDPE NET384 NET419 VDDCE PCH W=1U L=0.06U M=1 $name=/tpswitch/P00
M57 VDDPE NET477 GDLPRE VDDCE PCH W=1.5U L=0.06U M=1 $name=/tppreb/P00
M58 VDDPE NET342 GDLPRE VDDCE PCH W=1.5U L=0.06U M=1 $name=/tpprea/P00
M59 YSN NET364 NET509 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tppg2/P00
M6 HNET131 NET364 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gpnand/N11
M60 YSNI NET362 NET509 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tppg1/P00
M61 NET351 IOGTPD NET563 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tpgp2/P00
M62 DLOUT IOGTPD DIN VDDCE PCH W=0.49U L=0.06U M=1 $name=/tpdpass/P00
M63 VDDPE WE NET406 VDDCE PCH W=1U L=0.06U M=1 $name=/tgdlpukp/P00
M64 NET406 NET408 IODW_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/tgdlppgp/P00
M65 VDDPE GDLPRE GDL VDDCE PCH W=3U L=0.06U M=1 $name=/tgdlpch/P00
M66 NET518 NET408 IODW_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/tgdlnpgp/P00
M67 NET419 GDL_ GDL VDDCE PCH W=1U L=0.06U M=1 $name=/tgdlkeeperio/P00
M68 GDL GDLPRE GDL_ VDDCE PCH W=3U L=0.06U M=1 $name=/tgdleq/P00
M69 IODL NET406 VDDPE VDDCE PCH W=5U L=0.06U M=1 $name=/tgdldrvp/P00
M7 NET348 YSEL HNET131 VSSE NCH W=0.5U L=0.06U M=1 $name=/gpnand/N10
M70 NET419 GDL GDL_ VDDCE PCH W=1U L=0.06U M=1 $name=/tgdlbkeeper/P00
M71 NET550 NET408 IODW VDDCE PCH W=1.5U L=0.06U M=1 $name=/P7/P00
M72 WEI NET362 NET384 VDDCE PCH W=1U L=0.06U M=1 $name=/P6/P00
M73 VDDPE WE NET547 VDDCE PCH W=1U L=0.06U M=1 $name=/P55/P00
M74 WE NET364 NET384 VDDCE PCH W=1U L=0.06U M=1 $name=/P5/P00
M75 IODL_ NET547 VDDPE VDDCE PCH W=5U L=0.06U M=1 $name=/P43/P00
M76 GDL_ NET345 IODL_ VDDCE PCH W=3U L=0.06U M=1 $name=/P4/P00
M77 IODL NET345 GDL VDDCE PCH W=3U L=0.06U M=1 $name=/P3/P00
M78 VDDPE GDLPRE GDL_ VDDCE PCH W=3U L=0.06U M=1 $name=/P2/P00
M79 VDDPE QIE_P NET464 VDDCE PCH W=2.13U L=0.06U M=1 $name=/P18/P00
M8 HNET128 NET364 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gpnand/N01
M80 VDDPE QIE_P NET383 VDDCE PCH W=2.13U L=0.06U M=1 $name=/P13/P00
M81 NET547 NET408 IODW VDDCE PCH W=1.5U L=0.06U M=1 $name=/P12/P00
M82 NET464 IODL Q_ VDDCE PCH W=2.13U L=0.06U M=1 $name=/P11/P00
M83 GDLI NET348 IODL VDDCE PCH W=3U L=0.06U M=1 $name=/P1/P00
M84 GDLI_ NET348 IODL_ VDDCE PCH W=3U L=0.06U M=1 $name=/P0/P00
M85 VSSE IRETN NET490 VSSE NCH_HVT W=1U L=0.06U M=1 $name=/tqbpdretn/N00
M86 Q_ QILAT NET491 VSSE NCH_HVT W=1U L=0.06U M=1 $name=/tqbpd2/N00
M87 NET491 QIE_P NET490 VSSE NCH_HVT W=1U L=0.06U M=1 $name=/N20/N00
M88 NET491 IODL NET490 VSSE NCH_HVT W=1U L=0.06U M=1 $name=/N18/N00
M89 Q_ NET569 NET0483 VSSE NCH W=1.08U L=0.06U M=1 $name=/N1/N00
M9 NET348 YSEL HNET128 VSSE NCH W=0.5U L=0.06U M=1 $name=/gpnand/N00
M90 NET0483 QIE_N VSSE VSSE NCH W=1.08U L=0.06U M=1 $name=/N5/N00
M91 WEIN NET579 WELOUT VSSE NCH W=0.5U L=0.06U M=1 $name=/wpgn/N00
M92 Q_ NET569 NET545 VSSE NCH W=1.08U L=0.06U M=1 $name=/tqbpd/N00
M93 NET563 NET579 NET351 VSSE NCH W=0.2U L=0.06U M=1 $name=/tpgn2/N00
M94 NET481 NET477 VSSE VSSE NCH W=1.5U L=0.06U M=1 $name=/tnpreb/N00
M95 GDLPRE NET342 NET481 VSSE NCH W=1.5U L=0.06U M=1 $name=/tnprea/N00
M96 NET509 NET362 YSN VSSE NCH W=0.2U L=0.06U M=1 $name=/tnpg2/N00
M97 NET509 NET364 YSNI VSSE NCH W=0.2U L=0.06U M=1 $name=/tnpg1/N00
M98 DIN NET579 DLOUT VSSE NCH W=0.5U L=0.06U M=1 $name=/tndpass/N00
M99 IODW_ WE NET406 VSSE NCH W=1.5U L=0.06U M=1 $name=/tgdlppgn/N00
.ENDS icache_tag_storeIO4
****
.SUBCKT icache_tag_storeIO4EDGE CE_WE_TERM CRENA_TERM FIOGTP_TERM GDLA_TERM
+  GDLA__TERM IOGTP_TERM IRETN_TERM IRET_TERM TIEHIGH TIELOW TIELOW_TERM
+  WE_TERM YP0_TERM YP1_TERM YP2_TERM YP3_TERM YSNA_TERM VSSE VDDPE VDDCE
** icache_tag_storeIO4EDGE: 4 flat devices **
M0 VDDPE TIEHIGH TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M1 VDDPE TIELOW TIEHIGH VDDCE PCH W=4.9U L=0.06U M=1 $name=/P0/P00
M2 TIELOW TIEHIGH VSSE VSSE NCH W=3.15U L=0.06U M=1 $name=/tioarefn/N00
M3 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N3/N00
.ENDS icache_tag_storeIO4EDGE
****
.SUBCKT icache_tag_storeIO8RR11B1 BLTERM0_0 BLTERM0_1 BLTERM0_2 BLTERM0_3
+  BLTERM0_4 BLTERM0_5 BLTERM0_6 BLTERM0_7 BLTERM0_8 BLTERM0_9 BLTERM0_10
+  BLTERM0__0 BLTERM0__1 BLTERM0__2 BLTERM0__3 BLTERM0__4 BLTERM0__5
+  BLTERM0__6 BLTERM0__7 BLTERM0__8 BLTERM0__9 BLTERM0__10 BLTERM1_0 BLTERM1_1
+  BLTERM1_2 BLTERM1_3 BLTERM1_4 BLTERM1_5 BLTERM1_6 BLTERM1_7 BLTERM1_8
+  BLTERM1_9 BLTERM1_10 BLTERM1__0 BLTERM1__1 BLTERM1__2 BLTERM1__3 BLTERM1__4
+  BLTERM1__5 BLTERM1__6 BLTERM1__7 BLTERM1__8 BLTERM1__9 BLTERM1__10
+  BLTERM2_0 BLTERM2_1 BLTERM2_2 BLTERM2_3 BLTERM2_4 BLTERM2_5 BLTERM2_6
+  BLTERM2_7 BLTERM2_8 BLTERM2_9 BLTERM2_10 BLTERM2__0 BLTERM2__1 BLTERM2__2
+  BLTERM2__3 BLTERM2__4 BLTERM2__5 BLTERM2__6 BLTERM2__7 BLTERM2__8
+  BLTERM2__9 BLTERM2__10 BLTERM3_0 BLTERM3_1 BLTERM3_2 BLTERM3_3 BLTERM3_4
+  BLTERM3_5 BLTERM3_6 BLTERM3_7 BLTERM3_8 BLTERM3_9 BLTERM3_10 BLTERM3__0
+  BLTERM3__1 BLTERM3__2 BLTERM3__3 BLTERM3__4 BLTERM3__5 BLTERM3__6
+  BLTERM3__7 BLTERM3__8 BLTERM3__9 BLTERM3__10 BWEI_0 BWEI_1 BWEI_2 BWEI_3
+  BWEI_4 BWEI_5 BWEI_6 BWEI_7 BWEI_8 BWEI_9 BWEI_10 CE_WE CREN_0 CREN_1
+  CREN_2 CREN_3 CREN_4 CREN_5 CREN_6 CREN_7 CREN_8 CREN_9 CREN_10 DNI_0 DNI_1
+  DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9 DNI_10 FIOGTP GDLA GDL_0
+  GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL__0 GDL__1
+  GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 IOGTP IRET
+  IRETN Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9 Q__10 TIEHIGH
+  TIELOW YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE VDDCE
** icache_tag_storeIO8RR11B1: 1962 flat devices **
XRIGHTIO0 BLTERM0_0 BLTERM0__0 BLTERM1_0 BLTERM1__0 BLTERM2_0 BLTERM2__0
+  BLTERM3_0 BLTERM3__0 BWEI_0 CE_WE CREN_0 TIEHIGH TIEHIGH TIEHIGH DNI_0
+  FIOGTP GDL_0 GDLA TIEHIGH GDLA TIEHIGH GDLI_6 GDLI__8 GDL__0 IODL_12
+  IODL__10 IOGTP IRET IRETN Q__0 GDLA TIEHIGH GDLA WE_14 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_16 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XRIGHTIO1 BLTERM0_1 BLTERM0__1 BLTERM1_1 BLTERM1__1 BLTERM2_1 BLTERM2__1
+  BLTERM3_1 BLTERM3__1 BWEI_1 CE_WE CREN_1 TIEHIGH TIEHIGH TIEHIGH DNI_1
+  FIOGTP GDL_1 GDLA TIEHIGH GDLA TIEHIGH GDLI_18 GDLI__20 GDL__1 IODL_24
+  IODL__22 IOGTP IRET IRETN Q__1 GDLA TIEHIGH GDLA WE_26 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_28 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XRIGHTIO2 BLTERM0_2 BLTERM0__2 BLTERM1_2 BLTERM1__2 BLTERM2_2 BLTERM2__2
+  BLTERM3_2 BLTERM3__2 BWEI_2 CE_WE CREN_2 TIEHIGH TIEHIGH TIEHIGH DNI_2
+  FIOGTP GDL_2 GDLA TIEHIGH GDLA TIEHIGH GDLI_30 GDLI__32 GDL__2 IODL_36
+  IODL__34 IOGTP IRET IRETN Q__2 GDLA TIEHIGH GDLA WE_38 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_40 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XRIGHTIO3 BLTERM0_3 BLTERM0__3 BLTERM1_3 BLTERM1__3 BLTERM2_3 BLTERM2__3
+  BLTERM3_3 BLTERM3__3 BWEI_3 CE_WE CREN_3 TIEHIGH TIEHIGH TIEHIGH DNI_3
+  FIOGTP GDL_3 GDLA TIEHIGH GDLA TIEHIGH GDLI_42 GDLI__44 GDL__3 IODL_48
+  IODL__46 IOGTP IRET IRETN Q__3 GDLA TIEHIGH GDLA WE_50 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_52 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XRIGHTIO4 BLTERM0_4 BLTERM0__4 BLTERM1_4 BLTERM1__4 BLTERM2_4 BLTERM2__4
+  BLTERM3_4 BLTERM3__4 BWEI_4 CE_WE CREN_4 TIEHIGH TIEHIGH TIEHIGH DNI_4
+  FIOGTP GDL_4 GDLA TIEHIGH GDLA TIEHIGH GDLI_54 GDLI__56 GDL__4 IODL_60
+  IODL__58 IOGTP IRET IRETN Q__4 GDLA TIEHIGH GDLA WE_62 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_64 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XRIGHTIO5 BLTERM0_5 BLTERM0__5 BLTERM1_5 BLTERM1__5 BLTERM2_5 BLTERM2__5
+  BLTERM3_5 BLTERM3__5 BWEI_5 CE_WE CREN_5 TIEHIGH TIEHIGH TIEHIGH DNI_5
+  FIOGTP GDL_5 GDLA TIEHIGH GDLA TIEHIGH GDLI_66 GDLI__68 GDL__5 IODL_72
+  IODL__70 IOGTP IRET IRETN Q__5 GDLA TIEHIGH GDLA WE_74 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_76 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XRIGHTIO6 BLTERM0_6 BLTERM0__6 BLTERM1_6 BLTERM1__6 BLTERM2_6 BLTERM2__6
+  BLTERM3_6 BLTERM3__6 BWEI_6 CE_WE CREN_6 TIEHIGH TIEHIGH TIEHIGH DNI_6
+  FIOGTP GDL_6 GDLA TIEHIGH GDLA TIEHIGH GDLI_78 GDLI__80 GDL__6 IODL_84
+  IODL__82 IOGTP IRET IRETN Q__6 GDLA TIEHIGH GDLA WE_86 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_88 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XRIGHTIO7 BLTERM0_7 BLTERM0__7 BLTERM1_7 BLTERM1__7 BLTERM2_7 BLTERM2__7
+  BLTERM3_7 BLTERM3__7 BWEI_7 CE_WE CREN_7 TIEHIGH TIEHIGH TIEHIGH DNI_7
+  FIOGTP GDL_7 GDLA TIEHIGH GDLA TIEHIGH GDLI_90 GDLI__92 GDL__7 IODL_96
+  IODL__94 IOGTP IRET IRETN Q__7 GDLA TIEHIGH GDLA WE_98 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_100 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XRIGHTIO8 BLTERM0_8 BLTERM0__8 BLTERM1_8 BLTERM1__8 BLTERM2_8 BLTERM2__8
+  BLTERM3_8 BLTERM3__8 BWEI_8 CE_WE CREN_8 TIEHIGH TIEHIGH TIEHIGH DNI_8
+  FIOGTP GDL_8 GDLA TIEHIGH GDLA TIEHIGH GDLI_102 GDLI__104 GDL__8 IODL_108
+  IODL__106 IOGTP IRET IRETN Q__8 GDLA TIEHIGH GDLA WE_110 GDLA GDLA GDLA
+  YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_112 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE
+  VDDCE icache_tag_storeIO4
XRIGHTIO9 BLTERM0_9 BLTERM0__9 BLTERM1_9 BLTERM1__9 BLTERM2_9 BLTERM2__9
+  BLTERM3_9 BLTERM3__9 BWEI_9 CE_WE CREN_9 TIEHIGH TIEHIGH TIEHIGH DNI_9
+  FIOGTP GDL_9 GDLA TIEHIGH GDLA TIEHIGH GDLI_114 GDLI__116 GDL__9 IODL_120
+  IODL__118 IOGTP IRET IRETN Q__9 GDLA TIEHIGH GDLA WE_122 GDLA GDLA GDLA
+  YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_124 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE
+  VDDCE icache_tag_storeIO4
XRIGHTIOEDGE11 CE_WE TIEHIGH FIOGTP GDLA TIEHIGH IOGTP IRETN IRET TIEHIGH
+  TIELOW GDLA GDLA YP1_0 YP1_1 YP1_2 YP1_3 TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4EDGE
XRIGHTIOEXT10 BLTERM0_10 BLTERM0__10 BLTERM1_10 BLTERM1__10 BLTERM2_10
+  BLTERM2__10 BLTERM3_10 BLTERM3__10 BWEI_10 CE_WE CREN_10 TIEHIGH TIEHIGH
+  TIEHIGH DNI_10 FIOGTP GDL_10 GDLA TIEHIGH GDLA TIEHIGH GDLI GDLI_ GDL__10
+  IODL IODL_ IOGTP IRET IRETN Q__10 GDLA TIEHIGH GDLA WE GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
.ENDS icache_tag_storeIO8RR11B1
****
.SUBCKT icache_tag_storeCTRL4 AGTP AGTPN AX6N AY3 AY4 BS0N BS1N CEI CE_WE CLK
+  CREN_TERM EMA0 EMA1 EMA2 FIOGTPL FIOGTPR GDLA_TERM GDLA__TERM GTP GTPDE
+  GTPDEI GTPDET GTPDS GTPDSF GTPDST IOGTPL IOGTPR IRET IRETN LGWEN MBL MGDLE
+  MGDLET MGDLS MGDLST MGTPS MWLLATE PRDT PWBT RDT RETN RRENDD STOV TIEHIGH
+  TIELOW TL0_TERM WBTDD WEI WE_TERM YP1_0 YP1_1 YP1_2 YP1_3 YSNA_TERM VSSE
+  VDDPE VDDCE
** icache_tag_storeCTRL4: 373 flat devices **
D371 VSSE EMA1 NDIO 1.024e-07U 1.28U $name=/D5
D372 VSSE EMA2 NDIO 1.024e-07U 1.28U $name=/D4
M0 HNET182 NET665 VSSE VSSE NCH W=1.75U L=0.06U M=1 $name=/I14/N11
M1 AGTP GTPB HNET182 VSSE NCH W=1.75U L=0.06U M=1 $name=/I14/N10
M10 VDDPE DELAYEDGTP RESETGTP VDDCE PCH W=1.58U L=0.06U M=1 $name=/trstgtpw/P10
M100 NET610 AGTPN RGWEB VSSE NCH W=0.15U L=0.06U M=1 $name=/tpgwen2/N00
M101 NET536 AGTP WELOUT VSSE NCH W=0.15U L=0.06U M=1 $name=/tpgwen1/N00
M102 NET575 RGWEN NET0542 VSSE NCH W=0.15U L=0.06U M=1 $name=/tnpggtpde/N00
M103 GTP SETGTP NET547 VSSE NCH W=3U L=0.06U M=1 $name=/tgtpdrvn/N00
M104 NET552 GTP VSSE VSSE NCH W=0.75U L=0.06U M=1 $name=/tdlyn3/N00
M105 VSSE NET552 VSSE VSSE NCH W=0.3U L=0.12U M=1 $name=/tdlyn2b/N00
M106 MSI GTP VSSE VSSE NCH W=1.4U L=0.06U M=1 $name=/tdlyn1/N00
M107 SETGTP A CLKB VSSE NCH W=6.78U L=0.06U M=1 $name=/tclkbn/N00
M108 NET566 NET566 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N9/N00
M109 NET592 GTPB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N7/N00
M11 VDDPE DELAYEDMBL RESETGTP VDDCE PCH W=1.58U L=0.06U M=1 $name=/trstgtpw/P00
M110 NET547 GTPB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N6/N00
M111 NET575 RGWE NET789 VSSE NCH W=0.15U L=0.06U M=1 $name=/N31/N00
M112 NET578 TIELOW VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/N30/N00
M113 NET584 NET578 VSSE VSSE NCH W=0.45U L=0.12U M=1 $name=/N26/N00
M114 GTPDED NET575 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/N22/N00
M115 NET595 GTPB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N2/N00
M116 GTP SETGTP NET592 VSSE NCH W=3U L=0.06U M=1 $name=/N18/N00
M117 GTP SETGTP NET595 VSSE NCH W=3U L=0.06U M=1 $name=/N16/N00
M118 GTP SETGTP NET605 VSSE NCH W=3U L=0.06U M=1 $name=/N14/N00
M119 NET566 TIEHIGH VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/N10/N00
M12 HNET194 RESETGTP VSSE VSSE NCH W=2.31U L=0.06U M=1 $name=/tgtprsnd/N11
M120 NET605 GTPB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N1/N00
M121 NET610 RGWE VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv2/N00
M122 VDDPE RGWE NET610 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv2/P00
M123 NET536 NET810 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv1/N00
M124 VDDPE NET810 NET536 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv1/P00
M125 STOVB STOVI VSSE VSSE NCH_HVT W=0.23U L=0.06U M=1 $name=/stovsel/N00
M126 VDDPE STOVI STOVB VDDCE PCH_HVT W=0.32U L=0.06U M=1 $name=/stovsel/P00
M127 EMA00 EMA00B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/selinv/N00
M128 VDDPE EMA00B EMA00 VDDCE PCH_HVT W=0.17U L=0.06U M=1 $name=/selinv/P00
M129 NET713 EMA1N VSSE VSSE NCH_HVT W=0.22U L=0.06U M=1 $name=/sel1/N00
M13 GTPB GTP HNET194 VSSE NCH W=2.31U L=0.06U M=1 $name=/tgtprsnd/N10
M130 VDDPE EMA1N NET713 VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/sel1/P00
M131 NET715 EMA0N VSSE VSSE NCH_HVT W=0.22U L=0.06U M=1 $name=/sel0/N00
M132 VDDPE EMA0N NET715 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/sel0/P00
M133 MBLSELN MBLSEL VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/mblsel0/N00
M134 VDDPE MBLSEL MBLSELN VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/mblsel0/P00
M135 LONGEMA NET625 VSSE VSSE NCH_HVT W=0.25U L=0.06U M=1 $name=/longd4/N00
M136 VDDPE NET625 LONGEMA VDDCE PCH_HVT W=0.35U L=0.06U M=1 $name=/longd4/P00
M137 NET694 NET627 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/longd1/N00
M138 VDDPE NET627 NET694 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/longd1/P00
M139 NET631 MBLN VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gdlyinv2/N00
M14 HNET191 RESETGTP VSSE VSSE NCH W=2.31U L=0.06U M=1 $name=/tgtprsnd/N01
M140 VDDPE MBLN NET631 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/gdlyinv2/P00
M141 NET630 NET631 VSSE VSSE NCH_HVT W=0.18U L=0.06U M=1 $name=/gdlyinv1/N00
M142 VDDPE NET631 NET630 VDDCE PCH_HVT W=0.33U L=0.06U M=1 $name=/gdlyinv1/P00
M143 NET514 NET699 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv3/N00
M144 VDDPE NET699 NET514 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv3/P00
M145 NET700 NET635 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv2/N00
M146 VDDPE NET635 NET700 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv2/P00
M147 NET703 NET405 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv1/N00
M148 VDDPE NET405 NET703 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv1/P00
M149 NET407 NET639 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv0/N00
M15 GTPB GTP HNET191 VSSE NCH W=2.31U L=0.06U M=1 $name=/tgtprsnd/N00
M150 VDDPE NET639 NET407 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv0/P00
M151 NET640 PRDT VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I99/N00
M152 VDDPE PRDT NET640 VDDCE PCH_HVT W=0.41U L=0.06U M=1 $name=/I99/P00
M153 EMA10 EMA10B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I93/N00
M154 VDDPE EMA10B EMA10 VDDCE PCH_HVT W=0.17U L=0.06U M=1 $name=/I93/P00
M155 EMA11 EMA11B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I92/N00
M156 VDDPE EMA11B EMA11 VDDCE PCH_HVT W=0.17U L=0.06U M=1 $name=/I92/P00
M157 EMA01 EMA01B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I91/N00
M158 VDDPE EMA01B EMA01 VDDCE PCH_HVT W=0.17U L=0.06U M=1 $name=/I91/P00
M159 EMA0N EMA0 VSSE VSSE NCH_HVT W=0.44U L=0.06U M=1 $name=/I90/N00
M16 VDDCE RESETGTP GTPB VDDCE PCH W=3.54U L=0.06U M=1 $name=/tgtprsnd/P10
M160 VDDPE EMA0 EMA0N VDDCE PCH_HVT W=0.56U L=0.06U M=1 $name=/I90/P00
M161 NET688 STOV VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I89/N00
M162 VDDPE STOV NET688 VDDCE PCH_HVT W=0.42U L=0.06U M=1 $name=/I89/P00
M163 EMA2N EMA2 VSSE VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I88/N00
M164 VDDPE EMA2 EMA2N VDDCE PCH_HVT W=0.58U L=0.06U M=1 $name=/I88/P00
M165 EMA1N EMA1 VSSE VSSE NCH_HVT W=0.44U L=0.06U M=1 $name=/I87/N00
M166 VDDPE EMA1 EMA1N VDDCE PCH_HVT W=0.58U L=0.06U M=1 $name=/I87/P00
M167 HNET477 DELAYEDGTP VSSE VSSE NCH W=1.86U L=0.06U M=1 $name=/tsend/N01
M168 NET729 CLKB HNET477 VSSE NCH W=1.86U L=0.06U M=1 $name=/tsend/N00
M169 VDDPE DELAYEDGTP NET729 VDDCE PCH W=1.26U L=0.06U M=1 $name=/tsend/P10
M17 VDDCE GTP GTPB VDDCE PCH W=3.54U L=0.06U M=1 $name=/tgtprsnd/P00
M170 VDDPE CLKB NET729 VDDCE PCH W=1.26U L=0.06U M=1 $name=/tsend/P00
M171 HNET481 AY4 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/tioypnd/N01
M172 NET660 AY3 HNET481 VSSE NCH W=2.5U L=0.06U M=1 $name=/tioypnd/N00
M173 VDDPE AY4 NET660 VDDCE PCH W=2.5U L=0.06U M=1 $name=/tioypnd/P10
M174 VDDPE AY3 NET660 VDDCE PCH W=2.5U L=0.06U M=1 $name=/tioypnd/P00
M175 HNET485 RGWEN VSSE VSSE NCH W=0.75U L=0.06U M=1 $name=/tgtpdnd2/N01
M176 NET663 MGDLE HNET485 VSSE NCH W=0.75U L=0.06U M=1 $name=/tgtpdnd2/N00
M177 VDDPE RGWEN NET663 VDDCE PCH W=0.51U L=0.06U M=1 $name=/tgtpdnd2/P10
M178 VDDPE MGDLE NET663 VDDCE PCH W=0.51U L=0.06U M=1 $name=/tgtpdnd2/P00
M179 HNET489 NET663 VSSE VSSE NCH W=1.57U L=0.06U M=1 $name=/tgtpddrv3/N01
M18 HNET200 GTP VSSE VSSE NCH W=4U L=0.06U M=1 $name=/gfiogtpnd/N11
M180 NET666 NET665 HNET489 VSSE NCH W=1.57U L=0.06U M=1 $name=/tgtpddrv3/N00
M181 VDDPE NET663 NET666 VDDCE PCH W=1.07U L=0.06U M=1 $name=/tgtpddrv3/P10
M182 VDDPE NET665 NET666 VDDCE PCH W=1.07U L=0.06U M=1 $name=/tgtpddrv3/P00
M183 HNET493 AB VSSE VSSE NCH W=1.55U L=0.06U M=1 $name=/tgsetnd/N01
M184 NET798 GTPNDDW HNET493 VSSE NCH W=1.55U L=0.06U M=1 $name=/tgsetnd/N00
M185 VDDPE AB NET798 VDDCE PCH W=1.05U L=0.06U M=1 $name=/tgsetnd/P10
M186 VDDPE GTPNDDW NET798 VDDCE PCH W=1.05U L=0.06U M=1 $name=/tgsetnd/P00
M187 HNET497 CLKB VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/tclkce/N01
M188 CLKCE CEI HNET497 VSSE NCH W=0.3U L=0.06U M=1 $name=/tclkce/N00
M189 VDDPE CLKB CLKCE VDDCE PCH W=0.33U L=0.06U M=1 $name=/tclkce/P10
M19 DELAYEDMBL NET819 HNET200 VSSE NCH W=4U L=0.06U M=1 $name=/gfiogtpnd/N10
M190 VDDPE CEI CLKCE VDDCE PCH W=0.33U L=0.06U M=1 $name=/tclkce/P00
M191 HNET501 CLK VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/tcknd/N01
M192 NET675 RETDD HNET501 VSSE NCH W=0.18U L=0.06U M=1 $name=/tcknd/N00
M193 VDDPE CLK NET675 VDDCE PCH W=0.33U L=0.06U M=1 $name=/tcknd/P10
M194 VDDPE RETDD NET675 VDDCE PCH W=0.33U L=0.06U M=1 $name=/tcknd/P00
M195 HNET505 NET679 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I37/N01
M196 NET678 NET677 HNET505 VSSE NCH W=2.5U L=0.06U M=1 $name=/I37/N00
M197 VDDPE NET679 NET678 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I37/P10
M198 VDDPE NET677 NET678 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I37/P00
M199 HNET509 NET679 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I36/N01
M2 HNET179 NET665 VSSE VSSE NCH W=1.75U L=0.06U M=1 $name=/I14/N01
M20 HNET197 GTP VSSE VSSE NCH W=4U L=0.06U M=1 $name=/gfiogtpnd/N01
M200 NET681 AY3 HNET509 VSSE NCH W=2.5U L=0.06U M=1 $name=/I36/N00
M201 VDDPE NET679 NET681 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I36/P10
M202 VDDPE AY3 NET681 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I36/P00
M203 HNET513 AY4 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I35/N01
M204 NET826 NET677 HNET513 VSSE NCH W=2.5U L=0.06U M=1 $name=/I35/N00
M205 VDDPE AY4 NET826 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I35/P10
M206 VDDPE NET677 NET826 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I35/P00
M207 HNET517 NET688 VSSE VSSE NCH_HVT W=1.26U L=0.06U M=1 $name=/tstovnd/N01
M208 STOVI NET640 HNET517 VSSE NCH_HVT W=1.26U L=0.06U M=1 $name=/tstovnd/N00
M209 VDDPE NET688 STOVI VDDCE PCH_HVT W=0.86U L=0.06U M=1 $name=/tstovnd/P10
M21 DELAYEDMBL NET819 HNET197 VSSE NCH W=4U L=0.06U M=1 $name=/gfiogtpnd/N00
M210 VDDPE NET640 STOVI VDDCE PCH_HVT W=0.86U L=0.06U M=1 $name=/tstovnd/P00
M211 HNET521 EMA0N VSSE VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/selnand/N01
M212 EMA00B EMA1N HNET521 VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/selnand/N00
M213 VDDPE EMA0N EMA00B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/selnand/P10
M214 VDDPE EMA1N EMA00B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/selnand/P00
M215 HNET525 NET694 VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/longd3/N01
M216 NET625 DELAYEDGTP HNET525 VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/longd3/N00
M217 VDDPE NET694 NET625 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/longd3/P10
M218 VDDPE DELAYEDGTP NET625 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/longd3/P00
M219 HNET529 NET630 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/N01
M22 VDDPE GTP DELAYEDMBL VDDCE PCH W=8U L=0.06U M=1 $name=/gfiogtpnd/P10
M220 NET627 DELAYEDGTP HNET529 VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/N00
M221 VDDPE NET630 NET627 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/P10
M222 VDDPE DELAYEDGTP NET627 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/P00
M223 HNET533 NET700 VSSE VSSE NCH_HVT W=0.81U L=0.06U M=1 $name=/dlynand3/N01
M224 NET699 DELAYEDGTP HNET533 VSSE NCH_HVT W=0.81U L=0.06U M=1 $name=/dlynand3/N00
M225 VDDPE NET700 NET699 VDDCE PCH_HVT W=0.56U L=0.06U M=1 $name=/dlynand3/P10
M226 VDDPE DELAYEDGTP NET699 VDDCE PCH_HVT W=0.56U L=0.06U M=1 $name=/dlynand3/P00
M227 HNET537 NET703 VSSE VSSE NCH_HVT W=1.04U L=0.06U M=1 $name=/dlynand2/N01
M228 NET635 MBLN HNET537 VSSE NCH_HVT W=1.04U L=0.06U M=1 $name=/dlynand2/N00
M229 VDDPE NET703 NET635 VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/dlynand2/P10
M23 VDDPE NET819 DELAYEDMBL VDDCE PCH W=8U L=0.06U M=1 $name=/gfiogtpnd/P00
M230 VDDPE MBLN NET635 VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/dlynand2/P00
M231 HNET541 LONGEMA VSSE VSSE NCH_HVT W=1.07U L=0.06U M=1 $name=/dlynand0/N01
M232 NET639 DELAYEDGTP HNET541 VSSE NCH_HVT W=1.07U L=0.06U M=1 $name=/dlynand0/N00
M233 VDDPE LONGEMA NET639 VDDCE PCH_HVT W=0.73U L=0.06U M=1 $name=/dlynand0/P10
M234 VDDPE DELAYEDGTP NET639 VDDCE PCH_HVT W=0.73U L=0.06U M=1 $name=/dlynand0/P00
M235 HNET545 MBLN VSSE VSSE NCH_HVT W=1.86U L=0.06U M=1 $name=/dlydrv0/N01
M236 NET721 EMAPRE HNET545 VSSE NCH_HVT W=1.86U L=0.06U M=1 $name=/dlydrv0/N00
M237 VDDPE MBLN NET721 VDDCE PCH_HVT W=1.26U L=0.06U M=1 $name=/dlydrv0/P10
M238 VDDPE EMAPRE NET721 VDDCE PCH_HVT W=1.26U L=0.06U M=1 $name=/dlydrv0/P00
M239 HNET549 EMA0N VSSE VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I137/N01
M24 NET767 MWLLATE VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I33/N10
M240 EMA10B NET713 HNET549 VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I137/N00
M241 VDDPE EMA0N EMA10B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I137/P10
M242 VDDPE NET713 EMA10B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I137/P00
M243 HNET553 NET715 VSSE VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I136/N01
M244 EMA11B NET713 HNET553 VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I136/N00
M245 VDDPE NET715 EMA11B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I136/P10
M246 VDDPE NET713 EMA11B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I136/P00
M247 HNET557 NET715 VSSE VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I12/N01
M248 EMA01B EMA1N HNET557 VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I12/N00
M249 VDDPE NET715 EMA01B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I12/P10
M25 NET767 GTP VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I33/N00
M250 VDDPE EMA1N EMA01B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I12/P00
M251 HNET564 NET721 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I25/NI00
M252 STOVREMA STOVB HNET564 VSSE NCH W=0.3U L=0.06U M=1 $name=/I25/NE00
M253 HNET559 STOVI STOVREMA VDDCE PCH W=0.6U L=0.06U M=1 $name=/I25/PE00
M254 VDDCE NET721 HNET559 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I25/PI00
M255 HNET570 STOVREMA VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I28/NI00
M256 NET607 MBLSELN HNET570 VSSE NCH W=0.3U L=0.06U M=1 $name=/I28/NE00
M257 HNET565 MBLSEL NET607 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I28/PE00
M258 VDDCE STOVREMA HNET565 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I28/PI00
M259 HNET576 NET729 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I26/NI00
M26 VDDPE MWLLATE HNET202 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I33/P01
M260 STOVREMA STOVI HNET576 VSSE NCH W=0.3U L=0.06U M=1 $name=/I26/NE00
M261 HNET571 STOVB STOVREMA VDDCE PCH W=0.6U L=0.06U M=1 $name=/I26/PE00
M262 VDDCE NET729 HNET571 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I26/PI00
M263 HNET582 NET734 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tiretntri/NI00
M264 NET390 NET734 HNET582 VSSE NCH W=0.15U L=0.06U M=1 $name=/tiretntri/NE00
M265 HNET577 NET734 NET390 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tiretntri/PE00
M266 VDDCE NET734 HNET577 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tiretntri/PI00
M267 HNET588 MBLN VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I30/NI00
M268 NET607 MBLSEL HNET588 VSSE NCH W=0.3U L=0.06U M=1 $name=/I30/NE00
M269 HNET583 MBLSELN NET607 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I30/PE00
M27 HNET202 GTP NET767 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I33/P00
M270 VDDCE MBLN HNET583 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I30/PI00
M271 HNET594 IRET VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I10/NI00
M272 NET734 IRET HNET594 VSSE NCH W=0.15U L=0.06U M=1 $name=/I10/NE00
M273 HNET589 IRET NET734 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I10/PE00
M274 VDDCE IRET HNET589 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I10/PI00
M275 NET665 MGDLE VSSE VSSE NCH W=0.36U L=0.06U M=1 $name=/taptdrvb/N00
M276 VDDPE MGDLE NET665 VDDCE PCH W=0.75U L=0.06U M=1 $name=/taptdrvb/P00
M277 MGTPS NET747 VSSE VSSE NCH W=3U L=0.06U M=1 $name=/I7/N00
M278 VDDPE NET747 MGTPS VDDCE PCH W=6U L=0.06U M=1 $name=/I7/P00
M279 NET747 GTP VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/I8/N00
M28 NET776 NET389 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tiretnnor/N10
M280 VDDPE GTP NET747 VDDCE PCH W=2U L=0.06U M=1 $name=/I8/P00
M281 AGTPN AGTP VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I168/N00
M282 VDDPE AGTP AGTPN VDDCE PCH W=3.52U L=0.06U M=1 $name=/I168/P00
M283 GTPDSF NET789 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I24/N00
M284 VDDPE NET789 GTPDSF VDDCE PCH W=0.3U L=0.06U M=1 $name=/I24/P00
M285 NET606 NET607 VSSE VSSE NCH W=0.35U L=0.06U M=1 $name=/I31/N00
M286 VDDPE NET607 NET606 VDDCE PCH W=0.7U L=0.06U M=1 $name=/I31/P00
M287 WBTDD NET755 VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/twbtdrv/N00
M288 VDDPE NET755 WBTDD VDDCE PCH W=1.5U L=0.06U M=1 $name=/twbtdrv/P00
M289 NET755 PWBT VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/twbtb/N00
M29 NET776 NET390 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tiretnnor/N00
M290 VDDPE PWBT NET755 VDDCE PCH W=0.5U L=0.06U M=1 $name=/twbtb/P00
M291 IRET RETDD VSSE VSSE NCH W=3U L=0.06U M=1 $name=/tretdrv/N00
M292 VDDCE RETDD IRET VDDCE PCH W=6U L=0.06U M=1 $name=/tretdrv/P00
M293 RETDD NET389 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/tretdd/N00
M294 VDDCE NET389 RETDD VDDCE PCH W=1U L=0.06U M=1 $name=/tretdd/P00
M295 RDT NET763 VSSE VSSE NCH W=1.5U L=0.06U M=1 $name=/trdtdrv/N00
M296 VDDPE NET763 RDT VDDCE PCH W=3U L=0.06U M=1 $name=/trdtdrv/P00
M297 NET763 PRDT VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/trdtb/N00
M298 VDDPE PRDT NET763 VDDCE PCH W=1U L=0.06U M=1 $name=/trdtb/P00
M299 MBLN MBL VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/tmblndrv/N00
M3 AGTP GTPB HNET179 VSSE NCH W=1.75U L=0.06U M=1 $name=/I14/N00
M30 VDDCE NET389 HNET206 VDDCE PCH W=0.25U L=0.06U M=1 $name=/tiretnnor/P01
M300 VDDPE MBL MBLN VDDCE PCH W=1U L=0.06U M=1 $name=/tmblndrv/P00
M301 DELAYEDGTP NET767 VSSE VSSE NCH W=1.11U L=0.06U M=1 $name=/tlond/N00
M302 VDDPE NET767 DELAYEDGTP VDDCE PCH W=1.48U L=0.06U M=1 $name=/tlond/P00
M303 NET810 WELOUT VSSE VSSE NCH W=0.71U L=0.06U M=1 $name=/tlgweninv2/N00
M304 VDDPE WELOUT NET810 VDDCE PCH W=0.98U L=0.06U M=1 $name=/tlgweninv2/P00
M305 RGWE RGWEB VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tlgweninv1/N00
M306 VDDPE RGWEB RGWE VDDCE PCH W=0.2U L=0.06U M=1 $name=/tlgweninv1/P00
M307 IRETN NET774 VSSE VSSE NCH W=0.79U L=0.06U M=1 $name=/tiretndrv/N00
M308 VDDCE NET774 IRETN VDDCE PCH W=1.08U L=0.06U M=1 $name=/tiretndrv/P00
M309 NET774 NET776 VSSE VSSE NCH W=0.27U L=0.06U M=1 $name=/tiretnd/N00
M31 HNET206 NET390 NET776 VDDCE PCH W=0.25U L=0.06U M=1 $name=/tiretnnor/P00
M310 VDDCE NET776 NET774 VDDCE PCH W=0.36U L=0.06U M=1 $name=/tiretnd/P00
M311 YP1_3 NET660 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tioypdrv0/N00
M312 VDDPE NET660 YP1_3 VDDCE PCH W=10U L=0.06U M=1 $name=/tioypdrv0/P00
M313 NET677 AY3 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/tinvaydd/N00
M314 VDDPE AY3 NET677 VDDCE PCH W=1.6U L=0.06U M=1 $name=/tinvaydd/P00
M315 IOGTPR IOGTPN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tgtprstdrv/N00
M316 VDDPE IOGTPN IOGTPR VDDCE PCH W=10U L=0.06U M=1 $name=/tgtprstdrv/P00
M317 GTPNDDW NET787 VSSE VSSE NCH W=0.37U L=0.06U M=1 $name=/tgtpnddwdrv/N00
M318 VDDPE NET787 GTPNDDW VDDCE PCH W=0.5U L=0.06U M=1 $name=/tgtpnddwdrv/P00
M319 RGWEN RGWE VSSE VSSE NCH W=0.16U L=0.06U M=1 $name=/tgtpdinv/N00
M32 AB IRET VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/tabdrv/N10
M320 VDDPE RGWE RGWEN VDDCE PCH W=0.22U L=0.06U M=1 $name=/tgtpdinv/P00
M321 NET787 GTPB VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tgtpddwdrv/N00
M322 VDDPE GTPB NET787 VDDCE PCH W=0.17U L=0.06U M=1 $name=/tgtpddwdrv/P00
M323 NET789 NET666 VSSE VSSE NCH W=1.75U L=0.06U M=1 $name=/tgtpddrv2/N00
M324 VDDPE NET666 NET789 VDDCE PCH W=2.5U L=0.06U M=1 $name=/tgtpddrv2/P00
M325 GTPDS NET789 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/tgtpddrv1/N00
M326 VDDPE NET789 GTPDS VDDCE PCH W=7U L=0.06U M=1 $name=/tgtpddrv1/P00
M327 A NET798 VSSE VSSE NCH W=2.28U L=0.06U M=1 $name=/tgset3/N00
M328 VDDPE NET798 A VDDCE PCH W=3.1U L=0.06U M=1 $name=/tgset3/P00
M329 NET795 CLKCEGTPIN VSSE VSSE NCH W=0.77U L=0.06U M=1 $name=/tgset2/N00
M33 AB CLKCE VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/tabdrv/N00
M330 VDDPE CLKCEGTPIN NET795 VDDCE PCH W=1.05U L=0.06U M=1 $name=/tgset2/P00
M331 CLKCEGTPIN NET798 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tgset/N00
M332 VDDPE NET798 CLKCEGTPIN VDDCE PCH W=0.15U L=0.06U M=1 $name=/tgset/P00
M333 FIOGTPR DELAYEDMBL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tfiogtpdrv/N00
M334 VDDPE DELAYEDMBL FIOGTPR VDDCE PCH W=10U L=0.06U M=1 $name=/tfiogtpdrv/P00
M335 CKI NET675 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tckidrv/N00
M336 VDDPE NET675 CKI VDDCE PCH W=0.15U L=0.06U M=1 $name=/tckidrv/P00
M337 IWE WEI VSSE VSSE NCH W=1.5U L=0.06U M=1 $name=/tcewedrvb/N00
M338 VDDPE WEI IWE VDDCE PCH W=3U L=0.06U M=1 $name=/tcewedrvb/P00
M339 CE_WE IWE VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tcewedrv/N00
M34 VDDPE IRET HNET210 VDDCE PCH W=1.2U L=0.06U M=1 $name=/tabdrv/P01
M340 VDDPE IWE CE_WE VDDCE PCH W=10U L=0.06U M=1 $name=/tcewedrv/P00
M341 NET679 AY4 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/tay1/N00
M342 VDDPE AY4 NET679 VDDCE PCH W=1.6U L=0.06U M=1 $name=/tay1/P00
M343 LGWE NET810 VSSE VSSE NCH W=0.86U L=0.06U M=1 $name=/gwepdrv/N00
M344 VDDPE NET810 LGWE VDDCE PCH W=1.17U L=0.06U M=1 $name=/gwepdrv/P00
M345 LGWEN LGWE VSSE VSSE NCH W=2U L=0.06U M=1 $name=/gwedrv/N00
M346 VDDPE LGWE LGWEN VDDCE PCH W=4U L=0.06U M=1 $name=/gwedrv/P00
M347 MGDLS MSI VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gmgdldrv1/N00
M348 VDDPE MSI MGDLS VDDCE PCH W=5U L=0.06U M=1 $name=/gmgdldrv1/P00
M349 NET818 PIOGTPN VSSE VSSE NCH W=0.75U L=0.06U M=1 $name=/giogtpinv2/N00
M35 HNET210 CLKCE AB VDDCE PCH W=1.2U L=0.06U M=1 $name=/tabdrv/P00
M350 VDDPE PIOGTPN NET818 VDDCE PCH W=1.5U L=0.06U M=1 $name=/giogtpinv2/P00
M351 IOGTPN NET818 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/giogtpinv1/N00
M352 VDDPE NET818 IOGTPN VDDCE PCH W=5U L=0.06U M=1 $name=/giogtpinv1/P00
M353 NET819 NET606 VSSE VSSE NCH W=1.84U L=0.06U M=1 $name=/ginv1/N00
M354 VDDPE NET606 NET819 VDDCE PCH W=2.5U L=0.06U M=1 $name=/ginv1/P00
M355 IOGTPL IOGTPN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I53/N00
M356 VDDPE IOGTPN IOGTPL VDDCE PCH W=10U L=0.06U M=1 $name=/I53/P00
M357 YP1_0 NET678 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I41/N00
M358 VDDPE NET678 YP1_0 VDDCE PCH W=10U L=0.06U M=1 $name=/I41/P00
M359 YP1_2 NET826 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I40/N00
M36 PIOGTPN GTPDED VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/giogtpnor/N20
M360 VDDPE NET826 YP1_2 VDDCE PCH W=10U L=0.06U M=1 $name=/I40/P00
M361 YP1_1 NET681 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I39/N00
M362 VDDPE NET681 YP1_1 VDDCE PCH W=10U L=0.06U M=1 $name=/I39/P00
M363 TIELOW TIEHIGH VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I140/N00
M364 VDDPE TIEHIGH TIELOW VDDCE PCH W=0.9U L=0.06U M=1 $name=/I140/P00
M365 CLKB CLK VSSE VSSE NCH W=8.76U L=0.06U M=1 $name=/I127/N00
M366 VDDPE CLK CLKB VDDCE PCH W=13.2U L=0.06U M=1 $name=/I127/P00
M367 FIOGTPL DELAYEDMBL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I110/N00
M368 VDDPE DELAYEDMBL FIOGTPL VDDCE PCH W=10U L=0.06U M=1 $name=/I110/P00
M369 NET389 RETN VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/I0/N00
M37 PIOGTPN GTPDS VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/giogtpnor/N10
M370 VDDCE RETN NET389 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I0/P00
M38 PIOGTPN GTP VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/giogtpnor/N00
M39 VDDPE GTPDED HNET219 VDDCE PCH W=1U L=0.06U M=1 $name=/giogtpnor/P02
M4 VDDPE NET665 AGTP VDDCE PCH W=3.5U L=0.06U M=1 $name=/I14/P10
M40 HNET219 GTPDS HNET216 VDDCE PCH W=1U L=0.06U M=1 $name=/giogtpnor/P01
M41 HNET216 GTP PIOGTPN VDDCE PCH W=1U L=0.06U M=1 $name=/giogtpnor/P00
M42 HNET224 EMA0N VSSE VSSE NCH_HVT W=0.62U L=0.06U M=1 $name=/emanand0/N02
M43 HNET225 EMA1N HNET224 VSSE NCH_HVT W=0.62U L=0.06U M=1 $name=/emanand0/N01
M44 EMA000N EMA2N HNET225 VSSE NCH_HVT W=0.62U L=0.06U M=1 $name=/emanand0/N00
M45 VDDPE EMA0N EMA000N VDDCE PCH_HVT W=0.43U L=0.06U M=1 $name=/emanand0/P20
M46 VDDPE EMA1N EMA000N VDDCE PCH_HVT W=0.43U L=0.06U M=1 $name=/emanand0/P10
M47 VDDPE EMA2N EMA000N VDDCE PCH_HVT W=0.43U L=0.06U M=1 $name=/emanand0/P00
M48 MBLSEL EMA000N VSSE VSSE NCH_HVT W=0.4U L=0.06U M=1 $name=/mblsel1/N10
M49 MBLSEL STOVI VSSE VSSE NCH_HVT W=0.4U L=0.06U M=1 $name=/mblsel1/N00
M5 VDDPE GTPB AGTP VDDCE PCH W=3.5U L=0.06U M=1 $name=/I14/P00
M50 VDDPE EMA000N HNET226 VDDCE PCH_HVT W=0.8U L=0.06U M=1 $name=/mblsel1/P01
M51 HNET226 STOVI MBLSEL VDDCE PCH_HVT W=0.8U L=0.06U M=1 $name=/mblsel1/P00
M52 NET405 EMA2N VSSE VSSE NCH_HVT W=0.52U L=0.06U M=1 $name=/dlynord1/N10
M53 NET405 NET407 VSSE VSSE NCH_HVT W=0.52U L=0.06U M=1 $name=/dlynord1/N00
M54 VDDPE EMA2N HNET230 VDDCE PCH_HVT W=1.43U L=0.06U M=1 $name=/dlynord1/P01
M55 HNET230 NET407 NET405 VDDCE PCH_HVT W=1.43U L=0.06U M=1 $name=/dlynord1/P00
M56 VDDPE CKI SETGTP VDDCE PCH_HVT W=0.75U L=0.06U M=1 $name=/tgtpen/P00
M57 VDDPE GTP VDDPE VDDCE PCH_HVT W=0.3U L=0.12U M=1 $name=/tdlyp3b/P00
M58 NET407 EMA00B EMAPRE VDDCE PCH_HVT W=0.89U L=0.06U M=1 $name=/dlypassp/P00
M59 NET419 TIELOW NET578 VDDCE PCH_HVT W=0.45U L=0.12U M=1 $name=/P7/P00
M6 HNET188 DELAYEDGTP VSSE VSSE NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N11
M60 VDDPE TIELOW NET419 VDDCE PCH_HVT W=0.45U L=0.12U M=1 $name=/P6/P00
M61 NET514 EMA11B EMAPRE VDDCE PCH_HVT W=0.89U L=0.06U M=1 $name=/P29/P00
M62 NET700 EMA10B EMAPRE VDDCE PCH_HVT W=0.89U L=0.06U M=1 $name=/P28/P00
M63 NET703 EMA01B EMAPRE VDDCE PCH_HVT W=0.89U L=0.06U M=1 $name=/P25/P00
M64 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/P13/P00
M65 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/P12/P00
M66 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/P11/P00
M67 VDDPE GTPDEI NET0542 VDDCE PCH W=0.45U L=0.06U M=1 $name=/P15/P00
M68 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/P10/P00
M69 VDDPE GTPDEI VDDPE VDDCE PCH W=0.45U L=0.12U M=1 $name=/P14/P00
M7 RESETGTP DELAYEDMBL HNET188 VSSE NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N10
M70 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/P9/P00
M71 WELOUT AGTP WEI VDDCE PCH W=0.36U L=0.06U M=1 $name=/tpgwep4/P00
M72 RGWEB AGTPN NET810 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpgwep3/P00
M73 NET610 AGTP RGWEB VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpgwep2/P00
M74 NET536 AGTPN WELOUT VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpgwep1/P00
M75 VDDPE DELAYEDGTP MBL VDDCE PCH W=3U L=0.06U M=1 $name=/tkpmbl/P00
M76 VDDPE A SETGTP VDDCE PCH W=9.3U L=0.06U M=1 $name=/tgtpset/P00
M77 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/tgtpdrvp/P00
M78 VDDPE GTPB GTP VDDCE PCH W=6.3U L=0.06U M=1 $name=/tgpdrvp2/P00
M79 VDDPE GTP NET552 VDDCE PCH W=0.3U L=0.12U M=1 $name=/tdlyp3a/P00
M8 HNET185 DELAYEDGTP VSSE VSSE NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N01
M80 VDDPE NET552 NET555 VDDCE PCH W=0.36U L=0.06U M=1 $name=/tdlyp2/P00
M81 NET0486 GTP MSI VDDCE PCH W=0.45U L=0.06U M=1 $name=/tdlyp1/P00
M82 NET789 RGWEN NET575 VDDCE PCH W=0.3U L=0.06U M=1 $name=/P8/P00
M83 VDDPE NET578 NET518 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P5/P00
M84 VDDPE NET575 GTPDED VDDCE PCH W=0.15U L=0.06U M=1 $name=/P3/P00
M85 NET0542 RGWE NET575 VDDCE PCH W=0.3U L=0.06U M=1 $name=/P23/P00
M86 VDDPE GTP NET0486 VDDCE PCH W=0.45U L=0.12U M=1 $name=/P2/P00
M87 VDDPE TIEHIGH TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M88 VDDPE NET566 TIEHIGH VDDCE PCH W=0.9U L=0.06U M=1 $name=/P0/P00
M89 GTP IRET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N0/N00
M9 RESETGTP DELAYEDMBL HNET185 VSSE NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N00
M90 NET555 NET552 VSSE VSSE NCH_HVT W=0.3U L=0.12U M=1 $name=/tdlyn2a/N00
M91 EMAPRE EMA00 NET407 VSSE NCH_HVT W=0.89U L=0.06U M=1 $name=/dlypassn/N00
M92 EMAPRE EMA11 NET514 VSSE NCH_HVT W=0.89U L=0.06U M=1 $name=/N28/N00
M93 EMAPRE EMA10 NET700 VSSE NCH_HVT W=0.89U L=0.06U M=1 $name=/N27/N00
M94 NET518 NET578 NET584 VSSE NCH_HVT W=0.45U L=0.12U M=1 $name=/N25/N00
M95 EMAPRE EMA01 NET703 VSSE NCH_HVT W=0.89U L=0.06U M=1 $name=/N24/N00
M96 GTPDS IRET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N15/N00
M97 NET0542 GTPDEI VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/N3/N00
M98 WELOUT AGTPN WEI VSSE NCH W=0.36U L=0.06U M=1 $name=/tpgwen4/N00
M99 RGWEB AGTP NET810 VSSE NCH W=0.15U L=0.06U M=1 $name=/tpgwen3/N00
.ENDS icache_tag_storeCTRL4
****
.SUBCKT icache_tag_storeAL4 A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N A11N
+  A12N A13N AGTP AGTPN AI5 AI6 AI7 AI8 AI9 AI10 AI11 AI12 AI13 AX0N AX1N AX2N
+  AX3N AX4N AX5N AX6N AY0N AY1N AY2N AY3 AY4 BS0N BS1N BSN_MSB CE_WE_TRACK
+  FIOGTP_TRACK IOGTP_TRACK LAT11 LAT12 LAT13 MATCH0 MATCH1 MATCH2 MATCH3
+  RETN_TRACK RET_TRACK RREN RXP0 RXP1 RXP2 RXP3 TIEHIGH TIELOW YP0_TRACK
+  YP1_TRACK YP2_TRACK YP3_TRACK VSSE VDDPE VDDCE
** icache_tag_storeAL4: 194 flat devices **
M0 HNET124 NET465 VSSE VSSE NCH W=1.75U L=0.06U M=1 $name=/trrnand/N11
M1 NET524 NET474 HNET124 VSSE NCH W=1.75U L=0.06U M=1 $name=/trrnand/N10
M10 HNET137 AYL0 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I28/NI00
M100 NET509 MATCH0 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/trran/N00
M101 VDDPE MATCH0 NET509 VDDCE PCH W=0.7U L=0.06U M=1 $name=/trran/P00
M102 RXP1 NET505 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I5/N00
M103 VDDPE NET505 RXP1 VDDCE PCH W=2U L=0.06U M=1 $name=/I5/P00
M104 RXP0 NET509 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/trra/N00
M105 VDDPE NET509 RXP0 VDDCE PCH W=2U L=0.06U M=1 $name=/trra/P00
M106 RXP3 NET503 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I1/N00
M107 VDDPE NET503 RXP3 VDDCE PCH W=2U L=0.06U M=1 $name=/I1/P00
M108 RXP2 NET507 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I2/N00
M109 VDDPE NET507 RXP2 VDDCE PCH W=2U L=0.06U M=1 $name=/I2/P00
M11 AY0NLOUT AGTP HNET137 VSSE NCH W=0.2U L=0.06U M=1 $name=/I28/NE00
M110 AI12 NET520 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I96/N00
M111 VDDPE NET520 AI12 VDDCE PCH W=4U L=0.06U M=1 $name=/I96/P00
M112 AY1N NET353 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I30/N00
M113 VDDPE NET353 AY1N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I30/P00
M114 RREN NET524 VSSE VSSE NCH W=4.5U L=0.06U M=1 $name=/trrendrv/N00
M115 VDDPE NET524 RREN VDDCE PCH W=9U L=0.06U M=1 $name=/trrendrv/P00
M116 AI13 NET336 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/trre/N00
M117 VDDPE NET336 AI13 VDDCE PCH W=4U L=0.06U M=1 $name=/trre/P00
M118 NET337 NET336 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/taddrdrvb/N00
M119 VDDPE NET336 NET337 VDDCE PCH W=2U L=0.06U M=1 $name=/taddrdrvb/P00
M12 HNET132 AGTPN AY0NLOUT VDDCE PCH W=0.3U L=0.06U M=1 $name=/I28/PE00
M120 LAT13 NET337 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/taddrdrv/N00
M121 VDDPE NET337 LAT13 VDDCE PCH W=7.04U L=0.06U M=1 $name=/taddrdrv/P00
M122 NET531 NET520 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gaidriveb/N00
M123 VDDPE NET520 NET531 VDDCE PCH W=2U L=0.06U M=1 $name=/gaidriveb/P00
M124 NET533 BSN_MSB VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/grrinv3/N00
M125 VDDPE BSN_MSB NET533 VDDCE PCH W=2U L=0.06U M=1 $name=/grrinv3/P00
M126 NET535 BSN_MSB VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/grrinv2/N00
M127 VDDPE BSN_MSB NET535 VDDCE PCH W=2U L=0.06U M=1 $name=/grrinv2/P00
M128 NET537 MATCH1 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/grrinv1/N00
M129 VDDPE MATCH1 NET537 VDDCE PCH W=0.2U L=0.06U M=1 $name=/grrinv1/P00
M13 VDDPE AYL0 HNET132 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I28/PI00
M130 LAT12 NET531 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/gaidrive/N00
M131 VDDPE NET531 LAT12 VDDCE PCH W=7.04U L=0.06U M=1 $name=/gaidrive/P00
M132 LAT11 NET349 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I9/N00
M133 VDDPE NET349 LAT11 VDDCE PCH W=7.04U L=0.06U M=1 $name=/I9/P00
M134 NET543 MATCH2 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I70/N00
M135 VDDPE MATCH2 NET543 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I70/P00
M136 NET545 MATCH3 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I69/N00
M137 VDDPE MATCH3 NET545 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I69/P00
M138 NET547 MATCH0 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I3/N00
M139 VDDPE MATCH0 NET547 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I3/P00
M14 HNET143 NET531 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I7/NI00
M140 NET549 NET481 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I63/N00
M141 VDDPE NET481 NET549 VDDCE PCH W=2U L=0.06U M=1 $name=/I63/P00
M142 AI5 NET552 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I62/N00
M143 VDDPE NET552 AI5 VDDCE PCH W=4U L=0.06U M=1 $name=/I62/P00
M144 AXL0 NET552 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I60/N00
M145 VDDPE NET552 AXL0 VDDCE PCH W=2U L=0.06U M=1 $name=/I60/P00
M146 AI7 NET556 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I56/N00
M147 VDDPE NET556 AI7 VDDCE PCH W=4U L=0.06U M=1 $name=/I56/P00
M148 AI6 NET469 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I59/N00
M149 VDDPE NET469 AI6 VDDCE PCH W=4U L=0.06U M=1 $name=/I59/P00
M15 NET520 AGTP HNET143 VSSE NCH W=0.2U L=0.06U M=1 $name=/I7/NE00
M150 NET365 NET556 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I54/N00
M151 VDDPE NET556 NET365 VDDCE PCH W=2U L=0.06U M=1 $name=/I54/P00
M152 AX2N NET365 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I19/N00
M153 VDDPE NET365 AX2N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I19/P00
M154 NET563 NET469 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I57/N00
M155 VDDPE NET469 NET563 VDDCE PCH W=2U L=0.06U M=1 $name=/I57/P00
M156 AX1N NET563 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I18/N00
M157 VDDPE NET563 AX1N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I18/P00
M158 AI8 NET487 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I53/N00
M159 VDDPE NET487 AI8 VDDCE PCH W=4U L=0.06U M=1 $name=/I53/P00
M16 HNET138 AGTPN NET520 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I7/PE00
M160 NET569 NET487 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I51/N00
M161 VDDPE NET487 NET569 VDDCE PCH W=2U L=0.06U M=1 $name=/I51/P00
M162 NET369 NET574 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I50/N00
M163 VDDPE NET574 NET369 VDDCE PCH W=2U L=0.06U M=1 $name=/I50/P00
M164 AI9 NET574 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I48/N00
M165 VDDPE NET574 AI9 VDDCE PCH W=4U L=0.06U M=1 $name=/I48/P00
M166 NET353 NET352 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I65/N00
M167 VDDPE NET352 NET353 VDDCE PCH W=2U L=0.06U M=1 $name=/I65/P00
M168 AI10 NET493 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I43/N00
M169 VDDPE NET493 AI10 VDDCE PCH W=4U L=0.06U M=1 $name=/I43/P00
M17 VDDPE NET531 HNET138 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I7/PI00
M170 NET579 NET493 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I42/N00
M171 VDDPE NET493 NET579 VDDCE PCH W=2U L=0.06U M=1 $name=/I42/P00
M172 NET349 NET584 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I40/N00
M173 VDDPE NET584 NET349 VDDCE PCH W=2U L=0.06U M=1 $name=/I40/P00
M174 AI11 NET584 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I39/N00
M175 VDDPE NET584 AI11 VDDCE PCH W=4U L=0.06U M=1 $name=/I39/P00
M176 AYL0 AY0NLOUT VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I46/N00
M177 VDDPE AY0NLOUT AYL0 VDDCE PCH W=2U L=0.06U M=1 $name=/I46/P00
M178 AY0N AYL0 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I31/N00
M179 VDDPE AYL0 AY0N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I31/P00
M18 HNET149 NET349 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I11/NI00
M180 AY3 A3N VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/I27/N00
M181 VDDPE A3N AY3 VDDCE PCH W=2.4U L=0.06U M=1 $name=/I27/P00
M182 AY4 A4N VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/I26/N00
M183 VDDPE A4N AY4 VDDCE PCH W=2.4U L=0.06U M=1 $name=/I26/P00
M184 AY2N NET549 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I25/N00
M185 VDDPE NET549 AY2N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I25/P00
M186 AX0N AXL0 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I24/N00
M187 VDDPE AXL0 AX0N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I24/P00
M188 AX3N NET569 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I17/N00
M189 VDDPE NET569 AX3N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I17/P00
M19 NET584 AGTP HNET149 VSSE NCH W=0.2U L=0.06U M=1 $name=/I11/NE00
M190 AX4N NET369 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I16/N00
M191 VDDPE NET369 AX4N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I16/P00
M192 AX5N NET579 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I10/N00
M193 VDDPE NET579 AX5N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I10/P00
M2 HNET121 NET465 VSSE VSSE NCH W=1.75U L=0.06U M=1 $name=/trrnand/N01
M20 HNET144 AGTPN NET584 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I11/PE00
M21 VDDPE NET349 HNET144 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I11/PI00
M22 HNET155 NET353 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I22/NI00
M23 NET352 AGTP HNET155 VSSE NCH W=0.2U L=0.06U M=1 $name=/I22/NE00
M24 HNET150 AGTPN NET352 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I22/PE00
M25 VDDPE NET353 HNET150 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I22/PI00
M26 HNET161 NET549 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I23/NI00
M27 NET481 AGTP HNET161 VSSE NCH W=0.2U L=0.06U M=1 $name=/I23/NE00
M28 HNET156 AGTPN NET481 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I23/PE00
M29 VDDPE NET549 HNET156 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I23/PI00
M3 NET524 NET474 HNET121 VSSE NCH W=1.75U L=0.06U M=1 $name=/trrnand/N00
M30 HNET167 AXL0 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I20/NI00
M31 NET552 AGTP HNET167 VSSE NCH W=0.2U L=0.06U M=1 $name=/I20/NE00
M32 HNET162 AGTPN NET552 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I20/PE00
M33 VDDPE AXL0 HNET162 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I20/PI00
M34 HNET173 NET365 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I14/NI00
M35 NET556 AGTP HNET173 VSSE NCH W=0.2U L=0.06U M=1 $name=/I14/NE00
M36 HNET168 AGTPN NET556 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I14/PE00
M37 VDDPE NET365 HNET168 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I14/PI00
M38 HNET179 NET369 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I12/NI00
M39 NET574 AGTP HNET179 VSSE NCH W=0.2U L=0.06U M=1 $name=/I12/NE00
M4 VDDPE NET465 NET524 VDDCE PCH W=2.92U L=0.06U M=1 $name=/trrnand/P10
M40 HNET174 AGTPN NET574 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I12/PE00
M41 VDDPE NET369 HNET174 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I12/PI00
M42 HNET185 NET569 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I15/NI00
M43 NET487 AGTP HNET185 VSSE NCH W=0.2U L=0.06U M=1 $name=/I15/NE00
M44 HNET180 AGTPN NET487 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I15/PE00
M45 VDDPE NET569 HNET180 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I15/PI00
M46 HNET191 NET563 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I21/NI00
M47 NET469 AGTP HNET191 VSSE NCH W=0.2U L=0.06U M=1 $name=/I21/NE00
M48 HNET186 AGTPN NET469 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I21/PE00
M49 VDDPE NET563 HNET186 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I21/PI00
M5 VDDPE NET474 NET524 VDDCE PCH W=2.92U L=0.06U M=1 $name=/trrnand/P00
M50 HNET197 NET579 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I13/NI00
M51 NET493 AGTP HNET197 VSSE NCH W=0.2U L=0.06U M=1 $name=/I13/NE00
M52 HNET192 AGTPN NET493 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I13/PE00
M53 VDDPE NET579 HNET192 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I13/PI00
M54 NET469 AGTP A6N VDDCE PCH W=2U L=0.06U M=1 $name=/P36/P00
M55 NET535 NET537 NET465 VDDCE PCH W=1.2U L=0.06U M=1 $name=/trrpgp/P00
M56 NET535 NET547 NET465 VDDCE PCH W=1.2U L=0.06U M=1 $name=/P8/P00
M57 NET394 MATCH0 NET465 VDDCE PCH W=2U L=0.06U M=1 $name=/trrpu/P00
M58 VDDPE TIELOW TIEHIGH VDDCE PCH W=4.5U L=0.06U M=1 $name=/tarefp/P00
M59 NET336 AGTP A13N VDDCE PCH W=2U L=0.06U M=1 $name=/tapgp/P00
M6 HNET131 NET337 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I6/NI00
M60 NET552 AGTP A5N VDDCE PCH W=2U L=0.06U M=1 $name=/taiop2/P00
M61 AY0NLOUT AGTP A0N VDDCE PCH W=2U L=0.06U M=1 $name=/taiop/P00
M62 VDDPE MATCH1 NET394 VDDCE PCH W=2U L=0.06U M=1 $name=/P5/P00
M63 VDDPE TIEHIGH TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P79/P00
M64 VDDPE MATCH3 NET418 VDDCE PCH W=2U L=0.06U M=1 $name=/P4/P00
M65 NET418 MATCH2 NET474 VDDCE PCH W=2U L=0.06U M=1 $name=/P3/P00
M66 NET533 NET545 NET474 VDDCE PCH W=1.2U L=0.06U M=1 $name=/P2/P00
M67 NET533 NET543 NET474 VDDCE PCH W=1.2U L=0.06U M=1 $name=/P1/P00
M68 NET352 AGTP A1N VDDCE PCH W=2U L=0.06U M=1 $name=/P42/P00
M69 NET481 AGTP A2N VDDCE PCH W=2U L=0.06U M=1 $name=/P40/P00
M7 NET336 AGTP HNET131 VSSE NCH W=0.2U L=0.06U M=1 $name=/I6/NE00
M70 NET556 AGTP A7N VDDCE PCH W=2U L=0.06U M=1 $name=/P34/P00
M71 NET487 AGTP A8N VDDCE PCH W=2U L=0.06U M=1 $name=/P32/P00
M72 NET574 AGTP A9N VDDCE PCH W=2U L=0.06U M=1 $name=/P30/P00
M73 NET493 AGTP A10N VDDCE PCH W=2U L=0.06U M=1 $name=/P27/P00
M74 NET584 AGTP A11N VDDCE PCH W=2U L=0.06U M=1 $name=/P26/P00
M75 NET520 AGTP A12N VDDCE PCH W=2U L=0.06U M=1 $name=/P19/P00
M76 TIELOW TIEHIGH VSSE VSSE NCH W=3.3U L=0.06U M=1 $name=/tarefn/N00
M77 NET336 AGTPN A13N VSSE NCH W=2U L=0.06U M=1 $name=/tapgn/N00
M78 NET552 AGTPN A5N VSSE NCH W=2U L=0.06U M=1 $name=/taion2/N00
M79 AY0NLOUT AGTPN A0N VSSE NCH W=2U L=0.06U M=1 $name=/taion/N00
M8 HNET126 AGTPN NET336 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I6/PE00
M80 NET535 MATCH1 NET465 VSSE NCH W=1.2U L=0.06U M=1 $name=/trrpgn/N00
M81 NET535 MATCH0 NET465 VSSE NCH W=1.2U L=0.06U M=1 $name=/N4/N00
M82 NET469 AGTPN A6N VSSE NCH W=2U L=0.06U M=1 $name=/N37/N00
M83 NET533 MATCH3 NET474 VSSE NCH W=1.2U L=0.06U M=1 $name=/N2/N00
M84 NET533 MATCH2 NET474 VSSE NCH W=1.2U L=0.06U M=1 $name=/N1/N00
M85 NET352 AGTPN A1N VSSE NCH W=2U L=0.06U M=1 $name=/N43/N00
M86 NET481 AGTPN A2N VSSE NCH W=2U L=0.06U M=1 $name=/N41/N00
M87 NET556 AGTPN A7N VSSE NCH W=2U L=0.06U M=1 $name=/N35/N00
M88 NET487 AGTPN A8N VSSE NCH W=2U L=0.06U M=1 $name=/N33/N00
M89 NET574 AGTPN A9N VSSE NCH W=2U L=0.06U M=1 $name=/N31/N00
M9 VDDPE NET337 HNET126 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I6/PI00
M90 NET493 AGTPN A10N VSSE NCH W=2U L=0.06U M=1 $name=/N28/N00
M91 NET584 AGTPN A11N VSSE NCH W=2U L=0.06U M=1 $name=/N27/N00
M92 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N20/N00
M93 NET520 AGTPN A12N VSSE NCH W=2U L=0.06U M=1 $name=/N19/N00
M94 NET503 MATCH3 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/I94/N00
M95 VDDPE MATCH3 NET503 VDDCE PCH W=0.7U L=0.06U M=1 $name=/I94/P00
M96 NET505 MATCH1 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/I4/N00
M97 VDDPE MATCH1 NET505 VDDCE PCH W=0.7U L=0.06U M=1 $name=/I4/P00
M98 NET507 MATCH2 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/I0/N00
M99 VDDPE MATCH2 NET507 VDDCE PCH W=0.7U L=0.06U M=1 $name=/I0/P00
.ENDS icache_tag_storeAL4
****
.SUBCKT icache_tag_storeBCTRL21M4 A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N
+  A11N A12N A13N AX0N AX1N AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N BS0N BS1N
+  CEI CE_WE CLK CREN_TERM_0 CREN_TERM_1 EMA0 EMA1 EMA2 FIOGTP FIOGTPR
+  GDLA_TERM GDLA__TERM GDL_TERM GDL__TERM GTP GTPDET GTPDST IOGTP IOGTPR
+  LGWEN MATCH0 MATCH1 MATCH2 MATCH3 MBL MGDLET MGDLST MGTPS MWLLATE PRDT PWBT
+  RDT RETN RETN_TRACK RET_TRACK RRENDD RXP0 RXP1 RXP2 RXP3 STOV T0L_TERM
+  TIEHIGH_0 TIEHIGH_1 TIELOW_0 TIELOW_1 TL0_TERM WBTDD WEI WE_TERM_0
+  WE_TERM_1 YP0_TRACK YP1_TRACK YP2_TRACK YP3_TRACK YSNA_TERM_0 YSNA_TERM_1
+  VSSE VDDPE VDDCE
** icache_tag_storeBCTRL21M4: 567 flat devices **
XINSTAL A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N A11N A12N A13N AGTP AGTPN
+  AI5 AI6 AI7 AI8 AI9 AI10 AI11 AI12 AI13 AX0N AX1N AX2N AX3N AX4N AX5N AX6N
+  AY0N AY1N AY2N AY3 AY4 BS0N BS1N TIEHIGH_1 CE_WE FIOGTP IOGTP BS0N BS1N
+  AX6N MATCH0 MATCH1 MATCH2 MATCH3 RETN_TRACK RET_TRACK RRENDD RXP0 RXP1 RXP2
+  RXP3 TIEHIGH_1 TIELOW_1 YP0_TRACK YP1_TRACK YP2_TRACK YP3_TRACK VSSE VDDPE
+  VDDCE icache_tag_storeAL4
XINSTCTRL AGTP AGTPN AX6N AY3 AY4 BS0N BS1N CEI CE_WE CLK CREN_TERM_1 EMA0
+  EMA1 EMA2 FIOGTP FIOGTPR GDLA_TERM GDLA__TERM GTP GTPDST GTPDEI GTPDET
+  GTPDST GTPDEI GTPDST IOGTP IOGTPR RET_TRACK RETN_TRACK LGWEN MBL MGDLE
+  MGDLET MGDLE MGDLST MGTPS MWLLATE PRDT PWBT RDT RETN RRENDD STOV TIEHIGH_0
+  TIELOW_0 TL0_TERM WBTDD WEI WE_TERM_1 YP0_TRACK YP1_TRACK YP2_TRACK
+  YP3_TRACK YSNA_TERM_1 VSSE VDDPE VDDCE icache_tag_storeCTRL4
.ENDS icache_tag_storeBCTRL21M4
****
.SUBCKT icache_tag_storeIO8RL10B1 BLTERM0_0 BLTERM0_1 BLTERM0_2 BLTERM0_3
+  BLTERM0_4 BLTERM0_5 BLTERM0_6 BLTERM0_7 BLTERM0_8 BLTERM0_9 BLTERM0__0
+  BLTERM0__1 BLTERM0__2 BLTERM0__3 BLTERM0__4 BLTERM0__5 BLTERM0__6
+  BLTERM0__7 BLTERM0__8 BLTERM0__9 BLTERM1_0 BLTERM1_1 BLTERM1_2 BLTERM1_3
+  BLTERM1_4 BLTERM1_5 BLTERM1_6 BLTERM1_7 BLTERM1_8 BLTERM1_9 BLTERM1__0
+  BLTERM1__1 BLTERM1__2 BLTERM1__3 BLTERM1__4 BLTERM1__5 BLTERM1__6
+  BLTERM1__7 BLTERM1__8 BLTERM1__9 BLTERM2_0 BLTERM2_1 BLTERM2_2 BLTERM2_3
+  BLTERM2_4 BLTERM2_5 BLTERM2_6 BLTERM2_7 BLTERM2_8 BLTERM2_9 BLTERM2__0
+  BLTERM2__1 BLTERM2__2 BLTERM2__3 BLTERM2__4 BLTERM2__5 BLTERM2__6
+  BLTERM2__7 BLTERM2__8 BLTERM2__9 BLTERM3_0 BLTERM3_1 BLTERM3_2 BLTERM3_3
+  BLTERM3_4 BLTERM3_5 BLTERM3_6 BLTERM3_7 BLTERM3_8 BLTERM3_9 BLTERM3__0
+  BLTERM3__1 BLTERM3__2 BLTERM3__3 BLTERM3__4 BLTERM3__5 BLTERM3__6
+  BLTERM3__7 BLTERM3__8 BLTERM3__9 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5
+  BWEI_6 BWEI_7 BWEI_8 BWEI_9 CE_WE CREN_0 CREN_1 CREN_2 CREN_3 CREN_4 CREN_5
+  CREN_6 CREN_7 CREN_8 CREN_9 DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7
+  DNI_8 DNI_9 FIOGTP GDLA GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7
+  GDL_8 GDL_9 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8
+  GDL__9 IOGTP IRET IRETN Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9
+  TIEHIGH TIELOW YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE VDDCE
** icache_tag_storeIO8RL10B1: 1784 flat devices **
XLEFTIO0 BLTERM0_0 BLTERM0__0 BLTERM1_0 BLTERM1__0 BLTERM2_0 BLTERM2__0
+  BLTERM3_0 BLTERM3__0 BWEI_0 CE_WE CREN_0 TIEHIGH TIEHIGH TIEHIGH DNI_0
+  FIOGTP GDL_0 GDLA TIEHIGH GDLA TIEHIGH GDLI_6 GDLI__8 GDL__0 IODL_12
+  IODL__10 IOGTP IRET IRETN Q__0 GDLA TIEHIGH GDLA WE_14 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_16 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XLEFTIO1 BLTERM0_1 BLTERM0__1 BLTERM1_1 BLTERM1__1 BLTERM2_1 BLTERM2__1
+  BLTERM3_1 BLTERM3__1 BWEI_1 CE_WE CREN_1 TIEHIGH TIEHIGH TIEHIGH DNI_1
+  FIOGTP GDL_1 GDLA TIEHIGH GDLA TIEHIGH GDLI_18 GDLI__20 GDL__1 IODL_24
+  IODL__22 IOGTP IRET IRETN Q__1 GDLA TIEHIGH GDLA WE_26 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_28 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XLEFTIO2 BLTERM0_2 BLTERM0__2 BLTERM1_2 BLTERM1__2 BLTERM2_2 BLTERM2__2
+  BLTERM3_2 BLTERM3__2 BWEI_2 CE_WE CREN_2 TIEHIGH TIEHIGH TIEHIGH DNI_2
+  FIOGTP GDL_2 GDLA TIEHIGH GDLA TIEHIGH GDLI_30 GDLI__32 GDL__2 IODL_36
+  IODL__34 IOGTP IRET IRETN Q__2 GDLA TIEHIGH GDLA WE_38 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_40 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XLEFTIO3 BLTERM0_3 BLTERM0__3 BLTERM1_3 BLTERM1__3 BLTERM2_3 BLTERM2__3
+  BLTERM3_3 BLTERM3__3 BWEI_3 CE_WE CREN_3 TIEHIGH TIEHIGH TIEHIGH DNI_3
+  FIOGTP GDL_3 GDLA TIEHIGH GDLA TIEHIGH GDLI_42 GDLI__44 GDL__3 IODL_48
+  IODL__46 IOGTP IRET IRETN Q__3 GDLA TIEHIGH GDLA WE_50 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_52 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XLEFTIO4 BLTERM0_4 BLTERM0__4 BLTERM1_4 BLTERM1__4 BLTERM2_4 BLTERM2__4
+  BLTERM3_4 BLTERM3__4 BWEI_4 CE_WE CREN_4 TIEHIGH TIEHIGH TIEHIGH DNI_4
+  FIOGTP GDL_4 GDLA TIEHIGH GDLA TIEHIGH GDLI_54 GDLI__56 GDL__4 IODL_60
+  IODL__58 IOGTP IRET IRETN Q__4 GDLA TIEHIGH GDLA WE_62 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_64 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XLEFTIO5 BLTERM0_5 BLTERM0__5 BLTERM1_5 BLTERM1__5 BLTERM2_5 BLTERM2__5
+  BLTERM3_5 BLTERM3__5 BWEI_5 CE_WE CREN_5 TIEHIGH TIEHIGH TIEHIGH DNI_5
+  FIOGTP GDL_5 GDLA TIEHIGH GDLA TIEHIGH GDLI_66 GDLI__68 GDL__5 IODL_72
+  IODL__70 IOGTP IRET IRETN Q__5 GDLA TIEHIGH GDLA WE_74 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_76 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XLEFTIO6 BLTERM0_6 BLTERM0__6 BLTERM1_6 BLTERM1__6 BLTERM2_6 BLTERM2__6
+  BLTERM3_6 BLTERM3__6 BWEI_6 CE_WE CREN_6 TIEHIGH TIEHIGH TIEHIGH DNI_6
+  FIOGTP GDL_6 GDLA TIEHIGH GDLA TIEHIGH GDLI_78 GDLI__80 GDL__6 IODL_84
+  IODL__82 IOGTP IRET IRETN Q__6 GDLA TIEHIGH GDLA WE_86 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_88 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XLEFTIO7 BLTERM0_7 BLTERM0__7 BLTERM1_7 BLTERM1__7 BLTERM2_7 BLTERM2__7
+  BLTERM3_7 BLTERM3__7 BWEI_7 CE_WE CREN_7 TIEHIGH TIEHIGH TIEHIGH DNI_7
+  FIOGTP GDL_7 GDLA TIEHIGH GDLA TIEHIGH GDLI_90 GDLI__92 GDL__7 IODL_96
+  IODL__94 IOGTP IRET IRETN Q__7 GDLA TIEHIGH GDLA WE_98 GDLA GDLA GDLA YP1_0
+  YP1_0 YP1_1 YP1_2 YP1_3 YSN_100 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4
XLEFTIO8 BLTERM0_8 BLTERM0__8 BLTERM1_8 BLTERM1__8 BLTERM2_8 BLTERM2__8
+  BLTERM3_8 BLTERM3__8 BWEI_8 CE_WE CREN_8 TIEHIGH TIEHIGH TIEHIGH DNI_8
+  FIOGTP GDL_8 GDLA TIEHIGH GDLA TIEHIGH GDLI_102 GDLI__104 GDL__8 IODL_108
+  IODL__106 IOGTP IRET IRETN Q__8 GDLA TIEHIGH GDLA WE_110 GDLA GDLA GDLA
+  YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN_112 TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE
+  VDDCE icache_tag_storeIO4
XLEFTIOEDGE10 CE_WE TIEHIGH FIOGTP GDLA TIEHIGH IOGTP IRETN IRET TIEHIGH
+  TIELOW GDLA GDLA YP1_0 YP1_1 YP1_2 YP1_3 TIEHIGH VSSE VDDPE VDDCE
+  icache_tag_storeIO4EDGE
XLEFTIOEXT9 BLTERM0_9 BLTERM0__9 BLTERM1_9 BLTERM1__9 BLTERM2_9 BLTERM2__9
+  BLTERM3_9 BLTERM3__9 BWEI_9 CE_WE CREN_9 TIEHIGH TIEHIGH TIEHIGH DNI_9
+  FIOGTP GDL_9 GDLA TIEHIGH GDLA TIEHIGH GDLI GDLI_ GDL__9 IODL IODL_ IOGTP
+  IRET IRETN Q__9 GDLA TIEHIGH GDLA WE GDLA GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2
+  YP1_3 YSN TIEHIGH TIEHIGH TIEHIGH VSSE VDDPE VDDCE icache_tag_storeIO4
.ENDS icache_tag_storeIO8RL10B1
****
.SUBCKT icache_tag_storeBR21IO8B1 A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N
+  A11N A12N A13N AX0N AX1N AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N BLTERM0_0
+  BLTERM0_1 BLTERM0_2 BLTERM0_3 BLTERM0_4 BLTERM0_5 BLTERM0_6 BLTERM0_7
+  BLTERM0_8 BLTERM0_9 BLTERM0_10 BLTERM0_11 BLTERM0_12 BLTERM0_13 BLTERM0_14
+  BLTERM0_15 BLTERM0_16 BLTERM0_17 BLTERM0_18 BLTERM0_19 BLTERM0_20
+  BLTERM0__0 BLTERM0__1 BLTERM0__2 BLTERM0__3 BLTERM0__4 BLTERM0__5
+  BLTERM0__6 BLTERM0__7 BLTERM0__8 BLTERM0__9 BLTERM0__10 BLTERM0__11
+  BLTERM0__12 BLTERM0__13 BLTERM0__14 BLTERM0__15 BLTERM0__16 BLTERM0__17
+  BLTERM0__18 BLTERM0__19 BLTERM0__20 BLTERM1_0 BLTERM1_1 BLTERM1_2 BLTERM1_3
+  BLTERM1_4 BLTERM1_5 BLTERM1_6 BLTERM1_7 BLTERM1_8 BLTERM1_9 BLTERM1_10
+  BLTERM1_11 BLTERM1_12 BLTERM1_13 BLTERM1_14 BLTERM1_15 BLTERM1_16
+  BLTERM1_17 BLTERM1_18 BLTERM1_19 BLTERM1_20 BLTERM1__0 BLTERM1__1
+  BLTERM1__2 BLTERM1__3 BLTERM1__4 BLTERM1__5 BLTERM1__6 BLTERM1__7
+  BLTERM1__8 BLTERM1__9 BLTERM1__10 BLTERM1__11 BLTERM1__12 BLTERM1__13
+  BLTERM1__14 BLTERM1__15 BLTERM1__16 BLTERM1__17 BLTERM1__18 BLTERM1__19
+  BLTERM1__20 BLTERM2_0 BLTERM2_1 BLTERM2_2 BLTERM2_3 BLTERM2_4 BLTERM2_5
+  BLTERM2_6 BLTERM2_7 BLTERM2_8 BLTERM2_9 BLTERM2_10 BLTERM2_11 BLTERM2_12
+  BLTERM2_13 BLTERM2_14 BLTERM2_15 BLTERM2_16 BLTERM2_17 BLTERM2_18
+  BLTERM2_19 BLTERM2_20 BLTERM2__0 BLTERM2__1 BLTERM2__2 BLTERM2__3
+  BLTERM2__4 BLTERM2__5 BLTERM2__6 BLTERM2__7 BLTERM2__8 BLTERM2__9
+  BLTERM2__10 BLTERM2__11 BLTERM2__12 BLTERM2__13 BLTERM2__14 BLTERM2__15
+  BLTERM2__16 BLTERM2__17 BLTERM2__18 BLTERM2__19 BLTERM2__20 BLTERM3_0
+  BLTERM3_1 BLTERM3_2 BLTERM3_3 BLTERM3_4 BLTERM3_5 BLTERM3_6 BLTERM3_7
+  BLTERM3_8 BLTERM3_9 BLTERM3_10 BLTERM3_11 BLTERM3_12 BLTERM3_13 BLTERM3_14
+  BLTERM3_15 BLTERM3_16 BLTERM3_17 BLTERM3_18 BLTERM3_19 BLTERM3_20
+  BLTERM3__0 BLTERM3__1 BLTERM3__2 BLTERM3__3 BLTERM3__4 BLTERM3__5
+  BLTERM3__6 BLTERM3__7 BLTERM3__8 BLTERM3__9 BLTERM3__10 BLTERM3__11
+  BLTERM3__12 BLTERM3__13 BLTERM3__14 BLTERM3__15 BLTERM3__16 BLTERM3__17
+  BLTERM3__18 BLTERM3__19 BLTERM3__20 BS0N BS1N BWEI_0 BWEI_1 BWEI_2 BWEI_3
+  BWEI_4 BWEI_5 BWEI_6 BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12 BWEI_13
+  BWEI_14 BWEI_15 BWEI_16 BWEI_17 BWEI_18 BWEI_19 BWEI_20 CEI CLK CREN_0
+  CREN_1 CREN_2 CREN_3 CREN_4 CREN_5 CREN_6 CREN_7 CREN_8 CREN_9 CREN_10
+  CREN_11 CREN_12 CREN_13 CREN_14 CREN_15 CREN_16 CREN_17 CREN_18 CREN_19
+  CREN_20 DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9 DNI_10
+  DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 DNI_16 DNI_17 DNI_18 DNI_19 DNI_20 EMA0
+  EMA1 EMA2 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8
+  GDL__9 GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 GDL__16 GDL__17
+  GDL__18 GDL__19 GDL__20 GTP GTPDET GTPDST IRET IRETN LGWEN MATCH0 MATCH1
+  MATCH2 MATCH3 MBL MGDLET MGDLST MGTPS MWLLATE PRDT PWBT Q__0 Q__1 Q__2 Q__3
+  Q__4 Q__5 Q__6 Q__7 Q__8 Q__9 Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 Q__16
+  Q__17 Q__18 Q__19 Q__20 RDT RETN RRENDD RXP0 RXP1 RXP2 RXP3 STOV T0L_TERM
+  TIEHIGH_0 TIEHIGH_1 TIELOW_0 TIELOW_1 TIELOW_2 TL0_TERM WBTDD WEI VSSE
+  VDDPE VDDCE
** icache_tag_storeBR21IO8B1: 4313 flat devices **
XBOTCTRL A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N A11N A12N A13N AX0N AX1N
+  AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N BS0N BS1N CEI CE_WE CLK TIEHIGH_0
+  TIEHIGH_1 EMA0 EMA1 EMA2 FIOGTP_8 FIOGTP TIELOW_2 TIEHIGH_1 WE_TERM_0
+  TIEHIGH_0 GTP GTPDET GTPDST IOGTP_10 IOGTP LGWEN MATCH0 MATCH1 MATCH2
+  MATCH3 MBL MGDLET MGDLST MGTPS MWLLATE PRDT PWBT RDT RETN IRETN IRET RRENDD
+  RXP0 RXP1 RXP2 RXP3 STOV T0L_TERM TIEHIGH_1 TIEHIGH_0 TIELOW_2 WE_TERM_0
+  TL0_TERM WBTDD WEI WE_TERM_0 TIELOW_2 YP1_0 YP1_1 YP1_2 YP1_3 TIEHIGH_0
+  TIEHIGH_1 VSSE VDDPE VDDCE icache_tag_storeBCTRL21M4
XLEFTIOROW BLTERM0_9 BLTERM0_8 BLTERM0_7 BLTERM0_6 BLTERM0_5 BLTERM0_4
+  BLTERM0_3 BLTERM0_2 BLTERM0_1 BLTERM0_0 BLTERM0__9 BLTERM0__8 BLTERM0__7
+  BLTERM0__6 BLTERM0__5 BLTERM0__4 BLTERM0__3 BLTERM0__2 BLTERM0__1
+  BLTERM0__0 BLTERM1_9 BLTERM1_8 BLTERM1_7 BLTERM1_6 BLTERM1_5 BLTERM1_4
+  BLTERM1_3 BLTERM1_2 BLTERM1_1 BLTERM1_0 BLTERM1__9 BLTERM1__8 BLTERM1__7
+  BLTERM1__6 BLTERM1__5 BLTERM1__4 BLTERM1__3 BLTERM1__2 BLTERM1__1
+  BLTERM1__0 BLTERM2_9 BLTERM2_8 BLTERM2_7 BLTERM2_6 BLTERM2_5 BLTERM2_4
+  BLTERM2_3 BLTERM2_2 BLTERM2_1 BLTERM2_0 BLTERM2__9 BLTERM2__8 BLTERM2__7
+  BLTERM2__6 BLTERM2__5 BLTERM2__4 BLTERM2__3 BLTERM2__2 BLTERM2__1
+  BLTERM2__0 BLTERM3_9 BLTERM3_8 BLTERM3_7 BLTERM3_6 BLTERM3_5 BLTERM3_4
+  BLTERM3_3 BLTERM3_2 BLTERM3_1 BLTERM3_0 BLTERM3__9 BLTERM3__8 BLTERM3__7
+  BLTERM3__6 BLTERM3__5 BLTERM3__4 BLTERM3__3 BLTERM3__2 BLTERM3__1
+  BLTERM3__0 BWEI_9 BWEI_8 BWEI_7 BWEI_6 BWEI_5 BWEI_4 BWEI_3 BWEI_2 BWEI_1
+  BWEI_0 CE_WE CREN_9 CREN_8 CREN_7 CREN_6 CREN_5 CREN_4 CREN_3 CREN_2 CREN_1
+  CREN_0 DNI_9 DNI_8 DNI_7 DNI_6 DNI_5 DNI_4 DNI_3 DNI_2 DNI_1 DNI_0 FIOGTP_8
+  WE_TERM_0 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5 GDL_4 GDL_3 GDL_2 GDL_1 GDL_0
+  GDL__9 GDL__8 GDL__7 GDL__6 GDL__5 GDL__4 GDL__3 GDL__2 GDL__1 GDL__0
+  IOGTP_10 IRET IRETN Q__9 Q__8 Q__7 Q__6 Q__5 Q__4 Q__3 Q__2 Q__1 Q__0
+  TIEHIGH_0 TIELOW_0 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE VDDCE
+  icache_tag_storeIO8RL10B1
XRIGHTIOROW BLTERM0_10 BLTERM0_11 BLTERM0_12 BLTERM0_13 BLTERM0_14 BLTERM0_15
+  BLTERM0_16 BLTERM0_17 BLTERM0_18 BLTERM0_19 BLTERM0_20 BLTERM0__10
+  BLTERM0__11 BLTERM0__12 BLTERM0__13 BLTERM0__14 BLTERM0__15 BLTERM0__16
+  BLTERM0__17 BLTERM0__18 BLTERM0__19 BLTERM0__20 BLTERM1_10 BLTERM1_11
+  BLTERM1_12 BLTERM1_13 BLTERM1_14 BLTERM1_15 BLTERM1_16 BLTERM1_17
+  BLTERM1_18 BLTERM1_19 BLTERM1_20 BLTERM1__10 BLTERM1__11 BLTERM1__12
+  BLTERM1__13 BLTERM1__14 BLTERM1__15 BLTERM1__16 BLTERM1__17 BLTERM1__18
+  BLTERM1__19 BLTERM1__20 BLTERM2_10 BLTERM2_11 BLTERM2_12 BLTERM2_13
+  BLTERM2_14 BLTERM2_15 BLTERM2_16 BLTERM2_17 BLTERM2_18 BLTERM2_19
+  BLTERM2_20 BLTERM2__10 BLTERM2__11 BLTERM2__12 BLTERM2__13 BLTERM2__14
+  BLTERM2__15 BLTERM2__16 BLTERM2__17 BLTERM2__18 BLTERM2__19 BLTERM2__20
+  BLTERM3_10 BLTERM3_11 BLTERM3_12 BLTERM3_13 BLTERM3_14 BLTERM3_15
+  BLTERM3_16 BLTERM3_17 BLTERM3_18 BLTERM3_19 BLTERM3_20 BLTERM3__10
+  BLTERM3__11 BLTERM3__12 BLTERM3__13 BLTERM3__14 BLTERM3__15 BLTERM3__16
+  BLTERM3__17 BLTERM3__18 BLTERM3__19 BLTERM3__20 BWEI_10 BWEI_11 BWEI_12
+  BWEI_13 BWEI_14 BWEI_15 BWEI_16 BWEI_17 BWEI_18 BWEI_19 BWEI_20 CE_WE
+  CREN_10 CREN_11 CREN_12 CREN_13 CREN_14 CREN_15 CREN_16 CREN_17 CREN_18
+  CREN_19 CREN_20 DNI_10 DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 DNI_16 DNI_17
+  DNI_18 DNI_19 DNI_20 FIOGTP TIELOW_2 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL__10 GDL__11 GDL__12 GDL__13
+  GDL__14 GDL__15 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 IOGTP IRET IRETN
+  Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 Q__16 Q__17 Q__18 Q__19 Q__20 TIEHIGH_1
+  TIELOW_1 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE VDDCE icache_tag_storeIO8RR11B1
.ENDS icache_tag_storeBR21IO8B1
****
.SUBCKT icache_tag_storeCD4 BL0 BL0_ BL1 BL1_ BL2 BL2_ BL3 BL3_ BTP DR DRPREN
+  DR_ DW DW_ GDL GDL_ YP0N YP0_0N YP0_1N YP0_2N YP0_3N YP1N YP2N YP3N VSSE
+  VDDPE VDDCE
** icache_tag_storeCD4: 52 flat devices **
M0 BL0 YPPASS0 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/tblpass/P00
M1 BL1_ YPPASS1 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P14/P00
M10 BL3_ PRE0 BL3 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P28/P00
M11 BL0 PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/tpre/P00
M12 BL0_ PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P0/P00
M13 BL0_ PRE0 BL0 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P1/P00
M14 BL1 PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P13/P00
M15 BL1_ PRE0 BL1 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P12/P00
M16 BL3_ PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P27/P00
M17 BL3 PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P29/P00
M18 BL2_ PRE0 BL2 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P19/P00
M19 BL2 PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P18/P00
M2 BL0_ YPPASS0 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P53/P00
M20 BL1_ PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P11/P00
M21 VDDPE DRPREN DR_ VDDCE PCH W=0.17U L=0.06U M=1 $name=/P9/P00
M22 VDDPE DRPREN DR VDDCE PCH W=0.17U L=0.06U M=1 $name=/P8/P00
M23 VDDPE DW_ DR VDDCE PCH W=0.17U L=0.06U M=1 $name=/P7/P00
M24 VDDPE DW DR_ VDDCE PCH W=0.17U L=0.06U M=1 $name=/P5/P00
M25 BL0 YNPASS0 DW VSSE NCH W=1U L=0.06U M=1 $name=/P3/N00
M26 BL1 YNPASS1 DW VSSE NCH W=1U L=0.06U M=1 $name=/N2/N00
M27 BL0_ YNPASS0 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/P4/N00
M28 BL3_ YNPASS3 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/N9/N00
M29 BL2 YNPASS2 DW VSSE NCH W=1U L=0.06U M=1 $name=/N5/N00
M3 BL1 YPPASS1 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/P10/P00
M30 BL2_ YNPASS2 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/N4/N00
M31 BL3 YNPASS3 DW VSSE NCH W=1U L=0.06U M=1 $name=/N8/N00
M32 BL1_ YNPASS1 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/N3/N00
M33 YNPASS0 YP0N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I12/N00
M34 VDDPE YP0N YNPASS0 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I12/P00
M35 YPPASS0 YNPASS0 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I1/N00
M36 VDDPE YNPASS0 YPPASS0 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I1/P00
M37 YNPASS1 YP1N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I20/N00
M38 VDDPE YP1N YNPASS1 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I20/P00
M39 YPPASS1 YNPASS1 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I23/N00
M4 BL2_ YPPASS2 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P17/P00
M40 VDDPE YNPASS1 YPPASS1 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I23/P00
M41 YNPASS2 YP2N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I24/N00
M42 VDDPE YP2N YNPASS2 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I24/P00
M43 YPPASS2 YNPASS2 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I25/N00
M44 VDDPE YNPASS2 YPPASS2 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I25/P00
M45 YNPASS3 YP3N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I26/N00
M46 VDDPE YP3N YNPASS3 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I26/P00
M47 YPPASS3 YNPASS3 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I27/N00
M48 VDDPE YNPASS3 YPPASS3 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I27/P00
M49 NET160 BTP VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I3/N00
M5 BL3 YPPASS3 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/P26/P00
M50 VDDPE BTP NET160 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I3/P00
M51 PRE0 NET160 VSSE VSSE NCH_HVT W=0.44U L=0.06U M=1 $name=/N38/N00
M6 BL3_ YPPASS3 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P30/P00
M7 BL2 YPPASS2 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/P21/P00
M8 VDDPE NET160 PRE0 VDDCE PCH W=0.88U L=0.06U M=1 $name=/P73/P00
M9 BL2_ PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P20/P00
.ENDS icache_tag_storeCD4
****
.SUBCKT icache_tag_storeCDEDGE4 BTP DRPREN PG TIELOW YP0_0 YP0_1 YP0_2 YP0_3
+  VSSE VDDPE VDDCE
** icache_tag_storeCDEDGE4: 4 flat devices **
M0 VDDCE NET22 NET22 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M1 VDDCE TIELOW NET22 VDDCE PCH W=0.18U L=0.06U M=1 $name=/P0/P00
M2 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N3/N00
M3 TIELOW NET22 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N2/N00
.ENDS icache_tag_storeCDEDGE4
****
.SUBCKT icache_tag_storeCDROWRB021T BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0_8 BL0_9 BL0_10 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6
+  BL0__7 BL0__8 BL0__9 BL0__10 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6
+  BL1_7 BL1_8 BL1_9 BL1_10 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6
+  BL1__7 BL1__8 BL1__9 BL1__10 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6
+  BL2_7 BL2_8 BL2_9 BL2_10 BL2__0 BL2__1 BL2__2 BL2__3 BL2__4 BL2__5 BL2__6
+  BL2__7 BL2__8 BL2__9 BL2__10 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6
+  BL3_7 BL3_8 BL3_9 BL3_10 BL3__0 BL3__1 BL3__2 BL3__3 BL3__4 BL3__5 BL3__6
+  BL3__7 BL3__8 BL3__9 BL3__10 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5 DR_6
+  DR_7 DR_8 DR_9 DR_10 DR__0 DR__1 DR__2 DR__3 DR__4 DR__5 DR__6 DR__7 DR__8
+  DR__9 DR__10 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW__0
+  DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 GDL_0 GDL_1
+  GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL__0 GDL__1 GDL__2
+  GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 TIELOW YP0_0N
+  YP0_1N YP0_2N YP0_3N VSSE VDDPE VDDCE
** icache_tag_storeCDROWRB021T: 576 flat devices **
XCD41 BL0_0 BL0__0 BL1_0 BL1__0 BL2_0 BL2__0 BL3_0 BL3__0 BTP DR_0 DRPREN
+  DR__0 DW_0 DW__0 GDL_0 GDL__0 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD410 BL0_9 BL0__9 BL1_9 BL1__9 BL2_9 BL2__9 BL3_9 BL3__9 BTP DR_9 DRPREN
+  DR__9 DW_9 DW__9 GDL_9 GDL__9 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD411 BL0_10 BL0__10 BL1_10 BL1__10 BL2_10 BL2__10 BL3_10 BL3__10 BTP DR_10
+  DRPREN DR__10 DW_10 DW__10 GDL_10 GDL__10 YP0_0N YP0_0N YP0_1N YP0_2N
+  YP0_3N YP0_1N YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD42 BL0_1 BL0__1 BL1_1 BL1__1 BL2_1 BL2__1 BL3_1 BL3__1 BTP DR_1 DRPREN
+  DR__1 DW_1 DW__1 GDL_1 GDL__1 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD43 BL0_2 BL0__2 BL1_2 BL1__2 BL2_2 BL2__2 BL3_2 BL3__2 BTP DR_2 DRPREN
+  DR__2 DW_2 DW__2 GDL_2 GDL__2 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD44 BL0_3 BL0__3 BL1_3 BL1__3 BL2_3 BL2__3 BL3_3 BL3__3 BTP DR_3 DRPREN
+  DR__3 DW_3 DW__3 GDL_3 GDL__3 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD45 BL0_4 BL0__4 BL1_4 BL1__4 BL2_4 BL2__4 BL3_4 BL3__4 BTP DR_4 DRPREN
+  DR__4 DW_4 DW__4 GDL_4 GDL__4 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD46 BL0_5 BL0__5 BL1_5 BL1__5 BL2_5 BL2__5 BL3_5 BL3__5 BTP DR_5 DRPREN
+  DR__5 DW_5 DW__5 GDL_5 GDL__5 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD47 BL0_6 BL0__6 BL1_6 BL1__6 BL2_6 BL2__6 BL3_6 BL3__6 BTP DR_6 DRPREN
+  DR__6 DW_6 DW__6 GDL_6 GDL__6 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD48 BL0_7 BL0__7 BL1_7 BL1__7 BL2_7 BL2__7 BL3_7 BL3__7 BTP DR_7 DRPREN
+  DR__7 DW_7 DW__7 GDL_7 GDL__7 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD49 BL0_8 BL0__8 BL1_8 BL1__8 BL2_8 BL2__8 BL3_8 BL3__8 BTP DR_8 DRPREN
+  DR__8 DW_8 DW__8 GDL_8 GDL__8 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XI44 BTP DRPREN VDDCE TIELOW YP0_0N YP0_1N YP0_2N YP0_3N VSSE VDDPE VDDCE
+  icache_tag_storeCDEDGE4
.ENDS icache_tag_storeCDROWRB021T
****
.SUBCKT icache_tag_storeCDROWRT021T BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0_8 BL0_9 BL0_10 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6
+  BL0__7 BL0__8 BL0__9 BL0__10 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6
+  BL1_7 BL1_8 BL1_9 BL1_10 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6
+  BL1__7 BL1__8 BL1__9 BL1__10 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6
+  BL2_7 BL2_8 BL2_9 BL2_10 BL2__0 BL2__1 BL2__2 BL2__3 BL2__4 BL2__5 BL2__6
+  BL2__7 BL2__8 BL2__9 BL2__10 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6
+  BL3_7 BL3_8 BL3_9 BL3_10 BL3__0 BL3__1 BL3__2 BL3__3 BL3__4 BL3__5 BL3__6
+  BL3__7 BL3__8 BL3__9 BL3__10 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5 DR_6
+  DR_7 DR_8 DR_9 DR_10 DR__0 DR__1 DR__2 DR__3 DR__4 DR__5 DR__6 DR__7 DR__8
+  DR__9 DR__10 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW__0
+  DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 GDL_0 GDL_1
+  GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL__0 GDL__1 GDL__2
+  GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 TIELOW YP0_0N
+  YP0_1N YP0_2N YP0_3N VSSE VDDPE VDDCE
** icache_tag_storeCDROWRT021T: 576 flat devices **
XCD41 BL0_0 BL0__0 BL1_0 BL1__0 BL2_0 BL2__0 BL3_0 BL3__0 BTP DR_0 DRPREN
+  DR__0 DW_0 DW__0 GDL_0 GDL__0 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD410 BL0_9 BL0__9 BL1_9 BL1__9 BL2_9 BL2__9 BL3_9 BL3__9 BTP DR_9 DRPREN
+  DR__9 DW_9 DW__9 GDL_9 GDL__9 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD411 BL0_10 BL0__10 BL1_10 BL1__10 BL2_10 BL2__10 BL3_10 BL3__10 BTP DR_10
+  DRPREN DR__10 DW_10 DW__10 GDL_10 GDL__10 YP0_0N YP0_0N YP0_1N YP0_2N
+  YP0_3N YP0_1N YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD42 BL0_1 BL0__1 BL1_1 BL1__1 BL2_1 BL2__1 BL3_1 BL3__1 BTP DR_1 DRPREN
+  DR__1 DW_1 DW__1 GDL_1 GDL__1 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD43 BL0_2 BL0__2 BL1_2 BL1__2 BL2_2 BL2__2 BL3_2 BL3__2 BTP DR_2 DRPREN
+  DR__2 DW_2 DW__2 GDL_2 GDL__2 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD44 BL0_3 BL0__3 BL1_3 BL1__3 BL2_3 BL2__3 BL3_3 BL3__3 BTP DR_3 DRPREN
+  DR__3 DW_3 DW__3 GDL_3 GDL__3 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD45 BL0_4 BL0__4 BL1_4 BL1__4 BL2_4 BL2__4 BL3_4 BL3__4 BTP DR_4 DRPREN
+  DR__4 DW_4 DW__4 GDL_4 GDL__4 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD46 BL0_5 BL0__5 BL1_5 BL1__5 BL2_5 BL2__5 BL3_5 BL3__5 BTP DR_5 DRPREN
+  DR__5 DW_5 DW__5 GDL_5 GDL__5 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD47 BL0_6 BL0__6 BL1_6 BL1__6 BL2_6 BL2__6 BL3_6 BL3__6 BTP DR_6 DRPREN
+  DR__6 DW_6 DW__6 GDL_6 GDL__6 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD48 BL0_7 BL0__7 BL1_7 BL1__7 BL2_7 BL2__7 BL3_7 BL3__7 BTP DR_7 DRPREN
+  DR__7 DW_7 DW__7 GDL_7 GDL__7 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD49 BL0_8 BL0__8 BL1_8 BL1__8 BL2_8 BL2__8 BL3_8 BL3__8 BTP DR_8 DRPREN
+  DR__8 DW_8 DW__8 GDL_8 GDL__8 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XI44 BTP DRPREN VDDCE TIELOW YP0_0N YP0_1N YP0_2N YP0_3N VSSE VDDPE VDDCE
+  icache_tag_storeCDEDGE4
.ENDS icache_tag_storeCDROWRT021T
****
.SUBCKT icache_tag_storeXP4 ATRACK0 ATRACK0B ATRACK0T ATRACK1 ATRACK1B
+  ATRACK1T ATRACK2 ATRACK2B ATRACK2T ATRACK3 ATRACK3B ATRACK3T ATRACK4
+  ATRACK4B ATRACK4T ATRACK5 ATRACK5B ATRACK5T AX5N AX5NIN BTPB BTPBN BTPCDB
+  BTPCDT BTPSA BTPSAN BTPT BTPTN BTPWN BTPWNN DRPRENB DRPRENT PDRPREB PDRPRET
+  PGB_TERM PGT_TERM RET SAEN SAENN TIEHIGHB TIEHIGHT TIELOWB TIELOWT XP0 XP0_
+  XP1 XP1_ XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5 XP5_ YP0_0B YP0_0T YP0_1B YP0_1T
+  YP0_2B YP0_2T YP0_3B YP0_3T VSSE VDDPE VDDCE
** icache_tag_storeXP4: 143 flat devices **
M0 VDDPE A2_ NET168 VDDCE PCH W=1.1U L=0.06U M=1 $name=/txppnand/P00
M1 VDDPE A4 NET144 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P9/P00
M10 VDDPE AI0_ NET198 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P28/P00
M100 VDDPE NET268 A4_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/I61/P00
M101 XP3_ NET168 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I60/N00
M102 VDDPE NET168 XP3_ VDDCE PCH W=4U L=0.06U M=1 $name=/I60/P00
M103 A4 ATRACK4 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I59/N00
M104 VDDPE ATRACK4 A4 VDDCE PCH W=1.12U L=0.06U M=1 $name=/I59/P00
M105 XP4_ NET184 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I58/N00
M106 VDDPE NET184 XP4_ VDDCE PCH W=4U L=0.06U M=1 $name=/I58/P00
M107 XP4 NET93 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I57/N00
M108 VDDPE NET93 XP4 VDDCE PCH W=4U L=0.06U M=1 $name=/I57/P00
M109 A5_ NET291 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I56/N00
M11 VDDPE A1 NET210 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P25/P00
M110 VDDPE NET291 A5_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/I56/P00
M111 A5 AX5NIN VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I55/N00
M112 VDDPE AX5NIN A5 VDDCE PCH W=1.12U L=0.06U M=1 $name=/I55/P00
M113 XP5_ NET226 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I54/N00
M114 VDDPE NET226 XP5_ VDDCE PCH W=4U L=0.06U M=1 $name=/I54/P00
M115 BTPCDB NET0527 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I49/N00
M116 VDDPE NET0527 BTPCDB VDDCE PCH W=10.02U L=0.06U M=1 $name=/I49/P00
M117 BTPB BTPBN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I47/N00
M118 VDDPE BTPBN BTPB VDDCE PCH W=10.02U L=0.06U M=1 $name=/I47/P00
M119 NET268 ATRACK4 VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/I45/N00
M12 VDDPE AI0 NET108 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P24/P00
M120 VDDPE ATRACK4 NET268 VDDCE PCH W=0.38U L=0.06U M=1 $name=/I45/P00
M121 SAEN SAENN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I44/N00
M122 VDDPE SAENN SAEN VDDCE PCH W=10.02U L=0.06U M=1 $name=/I44/P00
M123 NET291 AX5NIN VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/I42/N00
M124 VDDPE AX5NIN NET291 VDDCE PCH W=0.38U L=0.06U M=1 $name=/I42/P00
M125 BTPT BTPTN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I40/N00
M126 VDDPE BTPTN BTPT VDDCE PCH W=10.02U L=0.06U M=1 $name=/I40/P00
M127 XP5 NET144 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I39/N00
M128 VDDPE NET144 XP5 VDDCE PCH W=4U L=0.06U M=1 $name=/I39/P00
M129 XP0_ NET198 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I35/N00
M13 VDDPE A1 NET108 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P23/P00
M130 VDDPE NET198 XP0_ VDDCE PCH W=4U L=0.06U M=1 $name=/I35/P00
M131 NET299 ATRACK2 VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/I34/N00
M132 VDDPE ATRACK2 NET299 VDDCE PCH W=0.38U L=0.06U M=1 $name=/I34/P00
M133 XP0 NET96 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I33/N00
M134 VDDPE NET96 XP0 VDDCE PCH W=4U L=0.06U M=1 $name=/I33/P00
M135 XP1 NET108 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I31/N00
M136 VDDPE NET108 XP1 VDDCE PCH W=4U L=0.06U M=1 $name=/I31/P00
M137 NET305 ATRACK1 VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/I30/N00
M138 VDDPE ATRACK1 NET305 VDDCE PCH W=0.38U L=0.06U M=1 $name=/I30/P00
M139 NET307 ATRACK0 VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/I29/N00
M14 VDDPE AI0_ NET210 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P22/P00
M140 VDDPE ATRACK0 NET307 VDDCE PCH W=0.38U L=0.06U M=1 $name=/I29/P00
M141 XP2_ NET222 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I28/N00
M142 VDDPE NET222 XP2_ VDDCE PCH W=4U L=0.06U M=1 $name=/I28/P00
M15 VDDPE A4 NET93 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P2/P00
M16 VDDPE A3_ NET222 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P19/P00
M17 VDDPE A2 NET123 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P18/P00
M18 VDDPE A3_ NET123 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P17/P00
M19 VDDPE A2_ NET222 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P16/P00
M2 NET184 A5_ VDDPE VDDCE PCH W=1.1U L=0.06U M=1 $name=/P8/P00
M20 NET226 A5 VDDPE VDDCE PCH W=1.1U L=0.06U M=1 $name=/P15/P00
M21 NET226 A4_ VDDPE VDDCE PCH W=1.1U L=0.06U M=1 $name=/P14/P00
M22 VDDPE A3 NET168 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P13/P00
M23 VDDPE A2 NET141 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P12/P00
M24 VDDPE A3 NET141 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P11/P00
M25 VDDPE A5 NET144 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P10/P00
M26 VDDPE TIELOWB NET150 VDDCE PCH W=4.8U L=0.06U M=1 $name=/P1/P00
M27 VDDPE NET150 NET150 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P0/P00
M28 VSSE RET DRPRENT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N24/N00
M29 VSSE RET DRPRENB VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N25/N00
M3 VDDPE NET78 NET78 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P57/P00
M30 VSSE RET BTPT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N9/N00
M31 VSSE RET BTPCDT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N6/N00
M32 VSSE RET BTPCDB VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N20/N00
M33 VSSE RET BTPB VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N19/N00
M34 VSSE RET BTPSA VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N15/N00
M35 NET172 A2_ NET168 VSSE NCH W=1.72U L=0.06U M=1 $name=/txpnnand/N00
M36 NET172 A2 NET141 VSSE NCH W=1.72U L=0.06U M=1 $name=/N8/N00
M37 NET172 A3 VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N7/N00
M38 TIELOWT TIELOWT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N60/N00
M39 TIELOWT NET78 VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N59/N00
M4 VDDPE TIELOWT NET78 VDDCE PCH W=4.8U L=0.06U M=1 $name=/P56/P00
M40 NET184 A4_ NET190 VSSE NCH W=1.72U L=0.06U M=1 $name=/N5/N00
M41 NET190 A5_ VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N4/N00
M42 NET190 A4 NET93 VSSE NCH W=1.72U L=0.06U M=1 $name=/N3/N00
M43 NET193 AI0 NET96 VSSE NCH W=1.72U L=0.06U M=1 $name=/N23/N00
M44 NET193 A1_ VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N22/N00
M45 NET193 AI0_ NET198 VSSE NCH W=1.72U L=0.06U M=1 $name=/N21/N00
M46 TIELOWB TIELOWB VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N2/N00
M47 NET205 AI0 NET108 VSSE NCH W=1.72U L=0.06U M=1 $name=/N18/N00
M48 NET205 A1 VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N17/N00
M49 NET205 AI0_ NET210 VSSE NCH W=1.72U L=0.06U M=1 $name=/N16/N00
M5 NET184 A4_ VDDPE VDDCE PCH W=1.1U L=0.06U M=1 $name=/P4/P00
M50 TIELOWB NET150 VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N14/N00
M51 NET217 A2 NET123 VSSE NCH W=1.72U L=0.06U M=1 $name=/N13/N00
M52 NET217 A3_ VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N12/N00
M53 NET217 A2_ NET222 VSSE NCH W=1.72U L=0.06U M=1 $name=/N11/N00
M54 NET226 A4_ NET232 VSSE NCH W=1.72U L=0.06U M=1 $name=/N10/N00
M55 NET232 A5 VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N1/N00
M56 NET232 A4 NET144 VSSE NCH W=1.72U L=0.06U M=1 $name=/N0/N00
M57 DRPRENT NET0515 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I1/N00
M58 VDDPE NET0515 DRPRENT VDDCE PCH W=10.02U L=0.06U M=1 $name=/I1/P00
M59 NET0515 PDRPRET VSSE VSSE NCH W=3.6U L=0.06U M=1 $name=/I4/N00
M6 VDDPE A1_ NET198 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P31/P00
M60 VDDPE PDRPRET NET0515 VDDCE PCH W=5U L=0.06U M=1 $name=/I4/P00
M61 NET0527 PDRPREB VSSE VSSE NCH W=3.6U L=0.06U M=1 $name=/I5/N00
M62 VDDPE PDRPREB NET0527 VDDCE PCH W=5U L=0.06U M=1 $name=/I5/P00
M63 DRPRENB NET0527 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I6/N00
M64 VDDPE NET0527 DRPRENB VDDCE PCH W=10.02U L=0.06U M=1 $name=/I6/P00
M65 NET233 ATRACK3 VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/tinvain/N00
M66 VDDPE ATRACK3 NET233 VDDCE PCH W=0.38U L=0.06U M=1 $name=/tinvain/P00
M67 A3_ NET233 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/tinvaidd/N00
M68 VDDPE NET233 A3_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/tinvaidd/P00
M69 A3 ATRACK3 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/tinvai/N00
M7 VDDPE AI0 NET96 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P30/P00
M70 VDDPE ATRACK3 A3 VDDCE PCH W=1.12U L=0.06U M=1 $name=/tinvai/P00
M71 BTPWN BTPWNN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpwnl/N00
M72 VDDPE BTPWNN BTPWN VDDCE PCH W=10.02U L=0.06U M=1 $name=/tbtpwnl/P00
M73 BTPSA BTPSAN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpsal/N00
M74 VDDPE BTPSAN BTPSA VDDCE PCH W=10.02U L=0.06U M=1 $name=/tbtpsal/P00
M75 BTPCDT NET0515 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpcdl/N00
M76 VDDPE NET0515 BTPCDT VDDCE PCH W=10.02U L=0.06U M=1 $name=/tbtpcdl/P00
M77 XP3 NET141 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/apdrv/N00
M78 VDDPE NET141 XP3 VDDCE PCH W=4U L=0.06U M=1 $name=/apdrv/P00
M79 TIEHIGHT TIELOWT VSSE VSSE NCH W=3U L=0.06U M=1 $name=/I96/N00
M8 VDDPE A5_ NET93 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P3/P00
M80 VDDPE TIELOWT TIEHIGHT VDDCE PCH W=4.8U L=0.06U M=1 $name=/I96/P00
M81 AI0_ NET307 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I81/N00
M82 VDDPE NET307 AI0_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/I81/P00
M83 AI0 ATRACK0 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I80/N00
M84 VDDPE ATRACK0 AI0 VDDCE PCH W=1.12U L=0.06U M=1 $name=/I80/P00
M85 A1_ NET305 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I79/N00
M86 VDDPE NET305 A1_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/I79/P00
M87 A1 ATRACK1 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I78/N00
M88 VDDPE ATRACK1 A1 VDDCE PCH W=1.12U L=0.06U M=1 $name=/I78/P00
M89 A2_ NET299 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I77/N00
M9 VDDPE A1_ NET96 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P29/P00
M90 VDDPE NET299 A2_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/I77/P00
M91 A2 ATRACK2 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I76/N00
M92 VDDPE ATRACK2 A2 VDDCE PCH W=1.12U L=0.06U M=1 $name=/I76/P00
M93 TIEHIGHB TIELOWB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/I64/N00
M94 VDDPE TIELOWB TIEHIGHB VDDCE PCH W=4.8U L=0.06U M=1 $name=/I64/P00
M95 XP1_ NET210 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I63/N00
M96 VDDPE NET210 XP1_ VDDCE PCH W=4U L=0.06U M=1 $name=/I63/P00
M97 XP2 NET123 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I62/N00
M98 VDDPE NET123 XP2 VDDCE PCH W=4U L=0.06U M=1 $name=/I62/P00
M99 A4_ NET268 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I61/N00
.ENDS icache_tag_storeXP4
****
.SUBCKT icache_tag_storeAPY4 AX5N AY0N AY0NB AY0NT AY1N AY1NB AY1NT AY2N AY2NB
+  AY2NT BSBN BSTN BTPB2_TERM BTPB3_TERM BTPT2_TERM BTPT3_TERM BTPWDB0 BTPWDB1
+  BTPWDT0 BTPWDT1 PBTPSA PBTPSAB PBTPSAT PBTPWN PDRPREB PDRPRET PSAEN RET
+  RXP0 RXP1 RXP2 RXP3 YP0_0NB YP0_0NT YP0_1NB YP0_1NT YP0_2NB YP0_2NT YP0_3NB
+  YP0_3NT VSSE VDDPE VDDCE
** icache_tag_storeAPY4: 108 flat devices **
M0 HNET95 AI1_ VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I0/N01
M1 AIND0T_ AI0_ HNET95 VSSE NCH W=0.8U L=0.06U M=1 $name=/I0/N00
M10 VDDPE AI1 AIND2T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I73/P10
M100 YP0_1NB YP1B VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I146/N00
M101 VDDPE YP1B YP0_1NB VDDCE PCH W=8U L=0.06U M=1 $name=/I146/P00
M102 YP0_0NB YP0B VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I145/N00
M103 VDDPE YP0B YP0_0NB VDDCE PCH W=8U L=0.06U M=1 $name=/I145/P00
M104 YP0_2NT YP2T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I144/N00
M105 VDDPE YP2T YP0_2NT VDDCE PCH W=8U L=0.06U M=1 $name=/I144/P00
M106 YP0_3NT YP3T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I143/N00
M107 VDDPE YP3T YP0_3NT VDDCE PCH W=8U L=0.06U M=1 $name=/I143/P00
M11 VDDPE AI0_ AIND2T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I73/P00
M12 HNET110 AI1 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I72/N01
M13 AIND3T_ AI0 HNET110 VSSE NCH W=0.8U L=0.06U M=1 $name=/I72/N00
M14 VDDPE AI1 AIND3T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I72/P10
M15 VDDPE AI0 AIND3T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I72/P00
M16 HNET115 AI1 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I152/N01
M17 AIND2B_ AI0_ HNET115 VSSE NCH W=0.8U L=0.06U M=1 $name=/I152/N00
M18 VDDPE AI1 AIND2B_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I152/P10
M19 VDDPE AI0_ AIND2B_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I152/P00
M2 VDDPE AI1_ AIND0T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I0/P10
M20 HNET120 AI1 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I151/N01
M21 AIND3B_ AI0 HNET120 VSSE NCH W=0.8U L=0.06U M=1 $name=/I151/N00
M22 VDDPE AI1 AIND3B_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I151/P10
M23 VDDPE AI0 AIND3B_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I151/P00
M24 HNET125 AI1_ VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I150/N01
M25 AIND1B_ AI0 HNET125 VSSE NCH W=0.8U L=0.06U M=1 $name=/I150/N00
M26 VDDPE AI1_ AIND1B_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I150/P10
M27 VDDPE AI0 AIND1B_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I150/P00
M28 HNET130 AI1_ VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I149/N01
M29 AIND0B_ AI0_ HNET130 VSSE NCH W=0.8U L=0.06U M=1 $name=/I149/N00
M3 VDDPE AI0_ AIND0T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I0/P00
M30 VDDPE AI1_ AIND0B_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I149/P10
M31 VDDPE AI0_ AIND0B_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I149/P00
M32 BST AIND0T_ YP0T VDDCE PCH W=2U L=0.06U M=1 $name=/P44/P00
M33 BST AIND1T_ YP1T VDDCE PCH W=2U L=0.06U M=1 $name=/P43/P00
M34 BST AIND2T_ YP2T VDDCE PCH W=2U L=0.06U M=1 $name=/P42/P00
M35 BST AIND3T_ YP3T VDDCE PCH W=2U L=0.06U M=1 $name=/P41/P00
M36 YP2B AIND2B_ BSB VDDCE PCH W=2U L=0.06U M=1 $name=/P3/P00
M37 YP3B AIND3B_ BSB VDDCE PCH W=2U L=0.06U M=1 $name=/P2/P00
M38 YP0B AIND0B_ BSB VDDCE PCH W=2U L=0.06U M=1 $name=/P1/P00
M39 YP1B AIND1B_ BSB VDDCE PCH W=2U L=0.06U M=1 $name=/P0/P00
M4 HNET100 AI1_ VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I77/N01
M40 BSB NET335 YP2B VSSE NCH W=2U L=0.06U M=1 $name=/N7/N00
M41 YP1T AIND1T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N62/N00
M42 YP0T AIND0T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N61/N00
M43 YP2T AIND2T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N60/N00
M44 BSB NET551 YP3B VSSE NCH W=2U L=0.06U M=1 $name=/N6/N00
M45 YP3T AIND3T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N59/N00
M46 YP1T NET497 BST VSSE NCH W=2U L=0.06U M=1 $name=/N55/N00
M47 YP0T NET365 BST VSSE NCH W=2U L=0.06U M=1 $name=/N54/N00
M48 YP2T NET368 BST VSSE NCH W=2U L=0.06U M=1 $name=/N53/N00
M49 YP3T NET503 BST VSSE NCH W=2U L=0.06U M=1 $name=/N52/N00
M5 AIND1T_ AI0 HNET100 VSSE NCH W=0.8U L=0.06U M=1 $name=/I77/N00
M50 YP2B AIND2B_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N5/N00
M51 VSSE AIND3B_ YP3B VSSE NCH W=1U L=0.06U M=1 $name=/N4/N00
M52 BSB NET389 YP0B VSSE NCH W=2U L=0.06U M=1 $name=/N3/N00
M53 BSB NET559 YP1B VSSE NCH W=2U L=0.06U M=1 $name=/N2/N00
M54 VSSE AIND1B_ YP1B VSSE NCH W=1U L=0.06U M=1 $name=/N1/N00
M55 YP0B AIND0B_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N0/N00
M56 NET485 NET527 VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/tain1/N00
M57 VDDPE NET527 NET485 VDDCE PCH W=0.5U L=0.06U M=1 $name=/tain1/P00
M58 BST BSTN VSSE VSSE NCH W=2U L=0.06U M=1 $name=/gbkselinv/N00
M59 VDDPE BSTN BST VDDCE PCH W=3.99U L=0.06U M=1 $name=/gbkselinv/P00
M6 VDDPE AI1_ AIND1T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I77/P10
M60 NET497 AIND1T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I79/N00
M61 VDDPE AIND1T_ NET497 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I79/P00
M62 NET365 AIND0T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I78/N00
M63 VDDPE AIND0T_ NET365 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I78/P00
M64 NET368 AIND2T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I75/N00
M65 VDDPE AIND2T_ NET368 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I75/P00
M66 NET503 AIND3T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I74/N00
M67 VDDPE AIND3T_ NET503 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I74/P00
M68 YP0_0NT YP0T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I67/N00
M69 VDDPE YP0T YP0_0NT VDDCE PCH W=8U L=0.06U M=1 $name=/I67/P00
M7 VDDPE AI0 AIND1T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I77/P00
M70 YP0_1NT YP1T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I66/N00
M71 VDDPE YP1T YP0_1NT VDDCE PCH W=8U L=0.06U M=1 $name=/I66/P00
M72 NET524 AY0N VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I179/N00
M73 VDDPE AY0N NET524 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I179/P00
M74 NET519 NET524 VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/I178/N00
M75 VDDPE NET524 NET519 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I178/P00
M76 AI0 NET519 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I177/N00
M77 VDDPE NET519 AI0 VDDCE PCH W=1.8U L=0.06U M=1 $name=/I177/P00
M78 AI0_ NET524 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I175/N00
M79 VDDPE NET524 AI0_ VDDCE PCH W=1.8U L=0.06U M=1 $name=/I175/P00
M8 HNET105 AI1 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I73/N01
M80 AI1_ NET527 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I173/N00
M81 VDDPE NET527 AI1_ VDDCE PCH W=1.8U L=0.06U M=1 $name=/I173/P00
M82 NET527 AY1N VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I172/N00
M83 VDDPE AY1N NET527 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I172/P00
M84 AI1 NET485 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I171/N00
M85 VDDPE NET485 AI1 VDDCE PCH W=1.8U L=0.06U M=1 $name=/I171/P00
M86 BSB BSBN VSSE VSSE NCH W=1.98U L=0.06U M=1 $name=/I157/N00
M87 VDDPE BSBN BSB VDDCE PCH W=3.99U L=0.06U M=1 $name=/I157/P00
M88 NET335 AIND2B_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I156/N00
M89 VDDPE AIND2B_ NET335 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I156/P00
M9 AIND2T_ AI0_ HNET105 VSSE NCH W=0.8U L=0.06U M=1 $name=/I73/N00
M90 NET551 AIND3B_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I155/N00
M91 VDDPE AIND3B_ NET551 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I155/P00
M92 YP0_3NB YP3B VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I154/N00
M93 VDDPE YP3B YP0_3NB VDDCE PCH W=8U L=0.06U M=1 $name=/I154/P00
M94 YP0_2NB YP2B VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I153/N00
M95 VDDPE YP2B YP0_2NB VDDCE PCH W=8U L=0.06U M=1 $name=/I153/P00
M96 NET389 AIND0B_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I148/N00
M97 VDDPE AIND0B_ NET389 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I148/P00
M98 NET559 AIND1B_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I147/N00
M99 VDDPE AIND1B_ NET559 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I147/P00
.ENDS icache_tag_storeAPY4
****
.SUBCKT icache_tag_storeCK4 AX5N AX6N AX6NB AX6NT AXIN BS0N BS0NB BS0NT BS1
+  BS1IN BS1N BS1NB BS1NT BS2 BS2IN BS2N BSBN BSTN BTPCDBR BTPCDTR BTPSABR
+  BTPSAR BTPSATR BTPWDB0 BTPWDB1 BTPWDT0 BTPWDT1 BTPWNR DRPRENBR DRPRENTR GTP
+  GTPB GTPD GTPDB GTPDE GTPDET GTPDT GTPT LGWEN MBL_TERM MGDLE MGDLET MGDLS
+  MGDLST MGTPE MGTPET MGTPS MGTPST PBTPSABL PBTPSAL PBTPSATL PBTPWNL PDRPREBL
+  PDRPRETL PGB_TERM PGT_TERM PSAENL RDT RET RREN RRENB RRENT SAENR TIEHIGH
+  TIELOW YP0_0B YP0_0T YP0_1B YP0_1T YP0_2B YP0_2T YP0_3B YP0_3T VSSE VDDPE
+  VDDCE
** icache_tag_storeCK4: 238 flat devices **
M0 BLKSELT0 NET990 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I50/N10
M1 BLKSELT0 NET967 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I50/N00
M10 VDDPE NET1002 HNET155 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I19/P01
M100 VSSE RET BTPWDB1 VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N27/N00
M101 VSSE RET BTPSAR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N9/N00
M102 VSSE RET BTPSATR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N8/N00
M103 VSSE RET BTPCDTR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N7/N00
M104 VSSE RET BTPWDT0 VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N6/N00
M105 VSSE RET BTPSABR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N4/N00
M106 VSSE RET DRPRENTR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N17/N00
M107 VSSE RET BTPCDBR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N13/N00
M108 VSSE RET DRPRENBR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N1/N00
M109 VSSE RET BTPWDB0 VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N0/N00
M11 HNET155 NET970 BLKSELB VDDCE PCH W=0.3U L=0.06U M=1 $name=/I19/P00
M110 HNET356 NET792 VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/I63/N01
M111 NET1011 GTP_CDSA HNET356 VSSE NCH W=0.52U L=0.06U M=1 $name=/I63/N00
M112 VDDPE NET792 NET1011 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I63/P10
M113 VDDPE GTP_CDSA NET1011 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I63/P00
M114 HNET360 BS2IN VSSE VSSE NCH W=0.21U L=0.06U M=1 $name=/I67/N01
M115 NET961 BS1IN HNET360 VSSE NCH W=0.21U L=0.06U M=1 $name=/I67/N00
M116 VDDPE BS2IN NET961 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I67/P10
M117 VDDPE BS1IN NET961 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I67/P00
M118 HNET364 NET976 VSSE VSSE NCH W=2.1U L=0.06U M=1 $name=/I31/N01
M119 PBTPWNL NET0612 HNET364 VSSE NCH W=2.1U L=0.06U M=1 $name=/I31/N00
M12 BLKSELBT AXIN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I18/N10
M120 VDDPE NET976 PBTPWNL VDDCE PCH W=2.9U L=0.06U M=1 $name=/I31/P10
M121 VDDPE NET0612 PBTPWNL VDDCE PCH W=2.9U L=0.06U M=1 $name=/I31/P00
M122 HNET368 BST VSSE VSSE NCH W=0.68U L=0.06U M=1 $name=/tnbst/N01
M123 NET967 NET986 HNET368 VSSE NCH W=0.68U L=0.06U M=1 $name=/tnbst/N00
M124 VDDPE BST NET967 VDDCE PCH W=0.46U L=0.06U M=1 $name=/tnbst/P10
M125 VDDPE NET986 NET967 VDDCE PCH W=0.46U L=0.06U M=1 $name=/tnbst/P00
M126 HNET372 NET1018 VSSE VSSE NCH W=0.68U L=0.06U M=1 $name=/tnbsb/N01
M127 NET970 NET986 HNET372 VSSE NCH W=0.68U L=0.06U M=1 $name=/tnbsb/N00
M128 VDDPE NET1018 NET970 VDDCE PCH W=0.46U L=0.06U M=1 $name=/tnbsb/P10
M129 VDDPE NET986 NET970 VDDCE PCH W=0.46U L=0.06U M=1 $name=/tnbsb/P00
M13 BLKSELBT NET970 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I18/N00
M130 HNET376 GTPD VSSE VSSE NCH W=1.28U L=0.06U M=1 $name=/tgnd2lat/N01
M131 NET825 PSAENL HNET376 VSSE NCH W=1.28U L=0.06U M=1 $name=/tgnd2lat/N00
M132 VDDPE GTPD NET825 VDDCE PCH W=0.88U L=0.06U M=1 $name=/tgnd2lat/P10
M133 VDDPE PSAENL NET825 VDDCE PCH W=0.88U L=0.06U M=1 $name=/tgnd2lat/P00
M134 HNET380 LGWE2 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/tbtpwnnd2/N01
M135 NET976 GTP_CDSA HNET380 VSSE NCH W=0.9U L=0.06U M=1 $name=/tbtpwnnd2/N00
M136 VDDPE LGWE2 NET976 VDDCE PCH W=0.8U L=0.06U M=1 $name=/tbtpwnnd2/P10
M137 VDDPE GTP_CDSA NET976 VDDCE PCH W=0.8U L=0.06U M=1 $name=/tbtpwnnd2/P00
M138 HNET384 NET980 VSSE VSSE NCH W=0.21U L=0.06U M=1 $name=/tbtpsnd2/N01
M139 NET979 NET986 HNET384 VSSE NCH W=0.21U L=0.06U M=1 $name=/tbtpsnd2/N00
M14 VDDPE AXIN HNET160 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I18/P01
M140 VDDPE NET980 NET979 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tbtpsnd2/P10
M141 VDDPE NET986 NET979 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tbtpsnd2/P00
M142 HNET388 NET798 VSSE VSSE NCH W=0.51U L=0.06U M=1 $name=/I62/N01
M143 NET1013 GTP_CDSA HNET388 VSSE NCH W=0.51U L=0.06U M=1 $name=/I62/N00
M144 VDDPE NET798 NET1013 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I62/P10
M145 VDDPE GTP_CDSA NET1013 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I62/P00
M146 NET0610 NET976 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I35/N00
M147 VDDPE NET976 NET0610 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I35/P00
M148 NET990 AXIN VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/I53/N00
M149 VDDPE AXIN NET990 VDDCE PCH W=0.42U L=0.06U M=1 $name=/I53/P00
M15 HNET160 NET970 BLKSELBT VDDCE PCH W=0.3U L=0.06U M=1 $name=/I18/P00
M150 BS2 BS2N VSSE VSSE NCH W=0.16U L=0.06U M=1 $name=/I65/N00
M151 VDDPE BS2N BS2 VDDCE PCH W=0.22U L=0.06U M=1 $name=/I65/P00
M152 NET986 NET961 VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I6/N00
M153 VDDPE NET961 NET986 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I6/P00
M154 BS1 BS1N VSSE VSSE NCH W=0.16U L=0.06U M=1 $name=/I7/N00
M155 VDDPE BS1N BS1 VDDCE PCH W=0.22U L=0.06U M=1 $name=/I7/P00
M156 GTPNT_WDT GTPT_WDT VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/I8/N00
M157 VDDPE GTPT_WDT GTPNT_WDT VDDCE PCH W=1.6U L=0.06U M=1 $name=/I8/P00
M158 BTPWDT1 GTPNT_WDT VSSE VSSE NCH W=2.49U L=0.06U M=1 $name=/I9/N00
M159 VDDPE GTPNT_WDT BTPWDT1 VDDCE PCH W=6U L=0.06U M=1 $name=/I9/P00
M16 RSELB LGWE2 VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/trselbnor2/N10
M160 BLKSELTN BLKSELT0 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I54/N00
M161 VDDPE BLKSELT0 BLKSELTN VDDCE PCH W=0.22U L=0.06U M=1 $name=/I54/P00
M162 BLKSELBNT BLKSELBT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I58/N00
M163 VDDPE BLKSELBT BLKSELBNT VDDCE PCH W=0.22U L=0.06U M=1 $name=/I58/P00
M164 NET1049 NET967 VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/I48/N00
M165 VDDPE NET967 NET1049 VDDCE PCH W=0.42U L=0.06U M=1 $name=/I48/P00
M166 NET1002 AXIN VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/I56/N00
M167 VDDPE AXIN NET1002 VDDCE PCH W=0.42U L=0.06U M=1 $name=/I56/P00
M168 GTPNB_WDT GTPB_WDT VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/I25/N00
M169 VDDPE GTPB_WDT GTPNB_WDT VDDCE PCH W=1.6U L=0.06U M=1 $name=/I25/P00
M17 RSELB BST VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/trselbnor2/N00
M170 BTPWDB1 GTPNB_WDT VSSE VSSE NCH W=2.49U L=0.06U M=1 $name=/I26/N00
M171 VDDPE GTPNB_WDT BTPWDB1 VDDCE PCH W=6U L=0.06U M=1 $name=/I26/P00
M172 BLKSELBN BLKSELB VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I57/N00
M173 VDDPE BLKSELB BLKSELBN VDDCE PCH W=0.22U L=0.06U M=1 $name=/I57/P00
M174 NET1010 NET1011 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I4/N00
M175 VDDPE NET1011 NET1010 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I4/P00
M176 NET1012 NET1013 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I1/N00
M177 VDDPE NET1013 NET1012 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I1/P00
M178 BLKSELTNT BLKSELT1 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I55/N00
M179 VDDPE BLKSELT1 BLKSELTNT VDDCE PCH W=0.22U L=0.06U M=1 $name=/I55/P00
M18 VDDPE LGWE2 HNET165 VDDCE PCH W=1.4U L=0.06U M=1 $name=/trselbnor2/P01
M180 NET1016 RREN VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/tsaseti/N00
M181 VDDPE RREN NET1016 VDDCE PCH W=1U L=0.06U M=1 $name=/tsaseti/P00
M182 NET1018 BST VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/tinvbs/N00
M183 VDDPE BST NET1018 VDDCE PCH W=0.6U L=0.06U M=1 $name=/tinvbs/P00
M184 NET1051 NET970 VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/tinv3/N00
M185 VDDPE NET970 NET1051 VDDCE PCH W=0.42U L=0.06U M=1 $name=/tinv3/P00
M186 SASELN SASEL VSSE VSSE NCH W=0.64U L=0.06U M=1 $name=/tinv2/N00
M187 VDDPE SASEL SASELN VDDCE PCH W=0.86U L=0.06U M=1 $name=/tinv2/P00
M188 SASEL NET979 VSSE VSSE NCH W=0.54U L=0.06U M=1 $name=/tinv1/N00
M189 VDDPE NET979 SASEL VDDCE PCH W=0.73U L=0.06U M=1 $name=/tinv1/P00
M19 HNET165 BST RSELB VDDCE PCH W=1.4U L=0.06U M=1 $name=/trselbnor2/P00
M190 NET0612 NET0610 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I36/N00
M191 VDDPE NET0610 NET0612 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I36/P00
M192 LGWE2 LGWEN VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/tbtpwninva/N00
M193 VDDPE LGWEN LGWE2 VDDCE PCH W=1.5U L=0.06U M=1 $name=/tbtpwninva/P00
M194 BTPWNR PBTPWNL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpwn/N00
M195 VDDPE PBTPWNL BTPWNR VDDCE PCH W=10U L=0.06U M=1 $name=/tbtpwn/P00
M196 GTPNT_WD GTPT_WD VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/tbtpwdn/N00
M197 VDDPE GTPT_WD GTPNT_WD VDDCE PCH W=1.6U L=0.06U M=1 $name=/tbtpwdn/P00
M198 BTPWDT0 GTPNT_WD VSSE VSSE NCH W=2.49U L=0.06U M=1 $name=/tbtpwd/N00
M199 VDDPE GTPNT_WD BTPWDT0 VDDCE PCH W=6U L=0.06U M=1 $name=/tbtpwd/P00
M2 VDDPE NET990 HNET145 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I50/P01
M20 NET792 RDT VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/tnr2t/N10
M200 BTPSATR PBTPSATL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpsatr/N00
M201 VDDPE PBTPSATL BTPSATR VDDCE PCH W=10U L=0.06U M=1 $name=/tbtpsatr/P00
M202 LGWEND LGWE2 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/tbtpsapredrv6/N00
M203 VDDPE LGWE2 LGWEND VDDCE PCH W=1.4U L=0.06U M=1 $name=/tbtpsapredrv6/P00
M204 SAENR PSAENL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpsaen/N00
M205 VDDPE PSAENL SAENR VDDCE PCH W=10U L=0.06U M=1 $name=/tbtpsaen/P00
M206 BTPSAR PBTPSAL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpsa/N00
M207 VDDPE PBTPSAL BTPSAR VDDCE PCH W=10U L=0.06U M=1 $name=/tbtpsa/P00
M208 BTPCDTR CDPRET VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpcd/N00
M209 VDDPE CDPRET BTPCDTR VDDCE PCH W=10U L=0.06U M=1 $name=/tbtpcd/P00
M21 NET792 NET1018 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/tnr2t/N00
M210 BST BS0N VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/tbs0/N00
M211 VDDPE BS0N BST VDDCE PCH W=0.9U L=0.06U M=1 $name=/tbs0/P00
M212 BSTN NET1049 VSSE VSSE NCH W=1.24U L=0.06U M=1 $name=/tbkselt2n/N00
M213 VDDPE NET1049 BSTN VDDCE PCH W=1.68U L=0.06U M=1 $name=/tbkselt2n/P00
M214 BSBN NET1051 VSSE VSSE NCH W=1.24U L=0.06U M=1 $name=/tbkselinv/N00
M215 VDDPE NET1051 BSBN VDDCE PCH W=1.68U L=0.06U M=1 $name=/tbkselinv/P00
M216 NET1052 NET1010 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I5/N00
M217 VDDPE NET1010 NET1052 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I5/P00
M218 CDPREB PDRPREBL VSSE VSSE NCH W=3.6U L=0.06U M=1 $name=/drprechdrvb/N00
M219 VDDPE PDRPREBL CDPREB VDDCE PCH W=5U L=0.06U M=1 $name=/drprechdrvb/P00
M22 VDDPE RDT HNET170 VDDCE PCH W=0.6U L=0.06U M=1 $name=/tnr2t/P01
M220 DRPRENBR CDPREB VSSE VSSE NCH W=5U L=0.06U M=1 $name=/drprechdrv/N00
M221 VDDPE CDPREB DRPRENBR VDDCE PCH W=10U L=0.06U M=1 $name=/drprechdrv/P00
M222 GTPNB_WD GTPB_WD VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/I210/N00
M223 VDDPE GTPB_WD GTPNB_WD VDDCE PCH W=1.6U L=0.06U M=1 $name=/I210/P00
M224 BTPCDBR CDPREB VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I208/N00
M225 VDDPE CDPREB BTPCDBR VDDCE PCH W=10U L=0.06U M=1 $name=/I208/P00
M226 DRPRENTR CDPRET VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I207/N00
M227 VDDPE CDPRET DRPRENTR VDDCE PCH W=10U L=0.06U M=1 $name=/I207/P00
M228 NET1064 NET1012 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I0/N00
M229 VDDPE NET1012 NET1064 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I0/P00
M23 HNET170 NET1018 NET792 VDDCE PCH W=0.6U L=0.06U M=1 $name=/tnr2t/P00
M230 CDPRET PDRPRETL VSSE VSSE NCH W=3.6U L=0.06U M=1 $name=/I205/N00
M231 VDDPE PDRPRETL CDPRET VDDCE PCH W=5U L=0.06U M=1 $name=/I205/P00
M232 NET980 RDT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I191/N00
M233 VDDPE RDT NET980 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I191/P00
M234 BTPWDB0 GTPNB_WD VSSE VSSE NCH W=2.49U L=0.06U M=1 $name=/I183/N00
M235 VDDPE GTPNB_WD BTPWDB0 VDDCE PCH W=6U L=0.06U M=1 $name=/I183/P00
M236 BTPSABR PBTPSABL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I175/N00
M237 VDDPE PBTPSABL BTPSABR VDDCE PCH W=10U L=0.06U M=1 $name=/I175/P00
M24 RSELT LGWE2 VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/tnr2prebtpsa/N10
M25 RSELT NET1018 VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/tnr2prebtpsa/N00
M26 VDDPE LGWE2 HNET175 VDDCE PCH W=1.4U L=0.06U M=1 $name=/tnr2prebtpsa/P01
M27 HNET175 NET1018 RSELT VDDCE PCH W=1.4U L=0.06U M=1 $name=/tnr2prebtpsa/P00
M28 NET798 RDT VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/tnr2b/N10
M29 NET798 BST VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/tnr2b/N00
M3 HNET145 NET967 BLKSELT0 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I50/P00
M30 VDDPE RDT HNET180 VDDCE PCH W=0.6U L=0.06U M=1 $name=/tnr2b/P01
M31 HNET180 BST NET798 VDDCE PCH W=0.6U L=0.06U M=1 $name=/tnr2b/P00
M32 HNET188 NET1011 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/I59/N11
M33 PDRPRETL NET1052 HNET188 VSSE NCH W=1.25U L=0.06U M=1 $name=/I59/N10
M34 HNET186 NET1011 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/I59/N01
M35 PDRPRETL NET1052 HNET186 VSSE NCH W=1.25U L=0.06U M=1 $name=/I59/N00
M36 VDDPE NET1011 PDRPRETL VDDCE PCH W=2.5U L=0.06U M=1 $name=/I59/P10
M37 VDDPE NET1052 PDRPRETL VDDCE PCH W=2.5U L=0.06U M=1 $name=/I59/P00
M38 HNET193 GTP_CDSA VSSE VSSE NCH W=1.16U L=0.06U M=1 $name=/tynand2/N11
M39 PBTPSATL RSELT HNET193 VSSE NCH W=1.16U L=0.06U M=1 $name=/tynand2/N10
M4 BLKSELT1 AXIN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I51/N10
M40 HNET191 GTP_CDSA VSSE VSSE NCH W=1.16U L=0.06U M=1 $name=/tynand2/N01
M41 PBTPSATL RSELT HNET191 VSSE NCH W=1.16U L=0.06U M=1 $name=/tynand2/N00
M42 VDDPE GTP_CDSA PBTPSATL VDDCE PCH W=1.5U L=0.06U M=1 $name=/tynand2/P10
M43 VDDPE RSELT PBTPSATL VDDCE PCH W=1.5U L=0.06U M=1 $name=/tynand2/P00
M44 HNET198 GTP_CDSA VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/tnand2/N11
M45 PBTPSABL RSELB HNET198 VSSE NCH W=1.2U L=0.06U M=1 $name=/tnand2/N10
M46 HNET196 GTP_CDSA VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/tnand2/N01
M47 PBTPSABL RSELB HNET196 VSSE NCH W=1.2U L=0.06U M=1 $name=/tnand2/N00
M48 VDDPE GTP_CDSA PBTPSABL VDDCE PCH W=1.5U L=0.06U M=1 $name=/tnand2/P10
M49 VDDPE RSELB PBTPSABL VDDCE PCH W=1.5U L=0.06U M=1 $name=/tnand2/P00
M5 BLKSELT1 NET967 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I51/N00
M50 HNET203 LGWEND VSSE VSSE NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N11
M51 PBTPSAL GTP_CDSA HNET203 VSSE NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N10
M52 HNET201 LGWEND VSSE VSSE NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N01
M53 PBTPSAL GTP_CDSA HNET201 VSSE NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N00
M54 VDDPE LGWEND PBTPSAL VDDCE PCH W=2.7U L=0.06U M=1 $name=/tbtpsapredrvnd2/P10
M55 VDDPE GTP_CDSA PBTPSAL VDDCE PCH W=2.7U L=0.06U M=1 $name=/tbtpsapredrvnd2/P00
M56 HNET208 NET1013 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/drprechnd2b/N11
M57 PDRPREBL NET1064 HNET208 VSSE NCH W=1.25U L=0.06U M=1 $name=/drprechnd2b/N10
M58 HNET206 NET1013 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/drprechnd2b/N01
M59 PDRPREBL NET1064 HNET206 VSSE NCH W=1.25U L=0.06U M=1 $name=/drprechnd2b/N00
M6 VDDPE AXIN HNET150 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I51/P01
M60 VDDPE NET1013 PDRPREBL VDDCE PCH W=2.5U L=0.06U M=1 $name=/drprechnd2b/P10
M61 VDDPE NET1064 PDRPREBL VDDCE PCH W=2.5U L=0.06U M=1 $name=/drprechnd2b/P00
M62 GTPT_WDT BLKSELTNT GTP VDDCE PCH W=0.6U L=0.06U M=1 $name=/P0/P00
M63 GTPB_WDT BLKSELBNT GTP VDDCE PCH W=0.6U L=0.06U M=1 $name=/P4/P00
M64 GTPT_WD BLKSELTN GTP VDDCE PCH W=0.6U L=0.06U M=1 $name=/twdpgp/P00
M65 PSAENL NET825 NET826 VDDCE PCH W=5.2U L=0.06U M=1 $name=/tsasetp2/P00
M66 NET826 PBTPSAL PSAENL VDDCE PCH W=6U L=0.06U M=1 $name=/tsasetp1/P00
M67 VDDPE NET1016 NET826 VDDCE PCH W=6U L=0.06U M=1 $name=/tsasetp/P00
M68 GTPB_WD BLKSELBN GTP VDDCE PCH W=0.6U L=0.06U M=1 $name=/tpp2/P00
M69 GTP_CDSA SASELN GTP VDDCE PCH W=4.98U L=0.06U M=1 $name=/tpp/P00
M7 HNET150 NET967 BLKSELT1 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I51/P00
M70 VDDPE MGDLE VDDPE VDDCE PCH W=0.2U L=0.06U M=1 $name=/tpcapgdlload/P00
M71 VDDPE TIELOW TIEHIGH VDDCE PCH W=5.01U L=0.06U M=1 $name=/P8/P00
M72 VDDPE TIEHIGH TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P3/P00
M73 VDDPE MGDLS VDDPE VDDCE PCH W=0.2U L=0.06U M=1 $name=/P2/P00
M74 VDDPE GTPDE VDDPE VDDCE PCH W=1.46U L=0.06U M=1 $name=/P10/P00
M75 GTPT_WDT BLKSELT1 GTP VSSE NCH W=0.6U L=0.06U M=1 $name=/N16/N00
M76 GTPT_WDT BLKSELTNT VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/N18/N00
M77 NET863 NET825 VSSE VSSE NCH W=1.86U L=0.06U M=1 $name=/N11/N00
M78 PSAENL PBTPSAL NET875 VSSE NCH W=1.86U L=0.06U M=1 $name=/N3/N00
M79 VSSE BLKSELBNT GTPB_WDT VSSE NCH W=0.4U L=0.06U M=1 $name=/N26/N00
M8 BLKSELB NET1002 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I19/N10
M80 GTPB_WDT BLKSELBT GTP VSSE NCH W=0.6U L=0.06U M=1 $name=/N25/N00
M81 NET875 NET825 VSSE VSSE NCH W=1.86U L=0.06U M=1 $name=/N5/N00
M82 PSAENL PBTPSAL NET863 VSSE NCH W=1.86U L=0.06U M=1 $name=/N10/N00
M83 GTPT_WD BLKSELT0 GTP VSSE NCH W=0.6U L=0.06U M=1 $name=/twdpgn/N00
M84 NET884 NET825 VSSE VSSE NCH W=1.86U L=0.06U M=1 $name=/tsasetn2/N00
M85 PSAENL NET1016 VSSE VSSE NCH W=2.28U L=0.06U M=1 $name=/tsasetn1/N00
M86 PSAENL PBTPSAL NET884 VSSE NCH W=1.86U L=0.06U M=1 $name=/tsasetn/N00
M87 GTPB_WD BLKSELB GTP VSSE NCH W=0.6U L=0.06U M=1 $name=/tpn2/N00
M88 GTP SASEL GTP_CDSA VSSE NCH W=4.98U L=0.06U M=1 $name=/tpn/N00
M89 MGDLE TIELOW VSSE VSSE NCH W=1U L=0.06U M=1 $name=/tpdcapgdlload/N00
M9 BLKSELB NET970 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I19/N00
M90 VSSE BLKSELBN GTPB_WD VSSE NCH W=0.4U L=0.06U M=1 $name=/tpd2/N00
M91 GTP_CDSA SASELN VSSE VSSE NCH W=2.66U L=0.06U M=1 $name=/tpd/N00
M92 VSSE MGDLE VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tncapgdlload/N00
M93 GTPT_WD BLKSELTN VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/tdwdkpn/N00
M94 VSSE GTPDE VSSE VSSE NCH W=2.12U L=0.06U M=1 $name=/N23/N00
M95 VSSE MGDLS VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N22/N00
M96 TIELOW TIEHIGH VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N20/N00
M97 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N2/N00
M98 MGDLS TIELOW VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N15/N00
M99 VSSE RET BTPWDT1 VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N19/N00
.ENDS icache_tag_storeCK4
****
.SUBCKT icache_tag_storeLOCDECB0BT ATRACK0B ATRACK0T ATRACK1B ATRACK1T
+  ATRACK2B ATRACK2T ATRACK3B ATRACK3T ATRACK4B ATRACK4T ATRACK5B ATRACK5T
+  AX6NT AY0NB AY0NT AY1NB AY1NT AY2NB AY2NT BS0NT BS1NT BTPB BTPB2_TERM
+  BTPB3_TERM BTPCDB BTPCDBR BTPCDT BTPCDTR BTPSA BTPSABR BTPSAR BTPSATR BTPT
+  BTPT2_TERM BTPT3_TERM BTPWDB0 BTPWDB1 BTPWDT0 BTPWDT1 BTPWN BTPWNR DRPRENB
+  DRPRENBR DRPRENT DRPRENTR GTPB GTPDET GTPT LGWEN MBL_TERM MGDLET MGTPE
+  MGTPET PGB_TERM_0 PGB_TERM_1 PGT_TERM_0 PGT_TERM_1 RDT RET RRENB RRENT RXP0
+  RXP1 RXP2 RXP3 SAEN SAENR TIEHIGHB TIEHIGHT TIELOWB TIELOWT XP0 XP0_ XP1
+  XP1_ XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5 XP5_ YP0_0B YP0_0T YP0_1B YP0_1T YP0_2B
+  YP0_2T YP0_3B YP0_3T VSSE VDDPE VDDCE
** icache_tag_storeLOCDECB0BT: 489 flat devices **
XI0 ATRACK0B ATRACK0B ATRACK0T ATRACK1B ATRACK1B ATRACK1T ATRACK2B ATRACK2B
+  ATRACK2T ATRACK3B ATRACK3B ATRACK3T ATRACK4B ATRACK4B ATRACK4T ATRACK5B
+  ATRACK5B ATRACK5T ATRACK5B TIEHIGHB BTPB BTPBN BTPCDB BTPCDT BTPSA BTPSAN
+  BTPT BTPTN BTPWN BTPWNN DRPRENB DRPRENT PDRPREB PDRPRET PGB_TERM_1
+  PGT_TERM_1 RET SAEN SAENN TIEHIGHB TIEHIGHT TIELOWB TIELOWT XP0 XP0_ XP1
+  XP1_ XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5 XP5_ YP0_0B YP0_0T YP0_1B YP0_1T YP0_2B
+  YP0_2T YP0_3B YP0_3T VSSE VDDPE VDDCE icache_tag_storeXP4
XI1 ATRACK5B AY0NB AY0NB AY0NT AY1NB AY1NB AY1NT AY2NB AY2NB AY2NT BSBN BSTN
+  BTPB2_TERM BTPB3_TERM BTPT2_TERM BTPT3_TERM BTPWDB0 BTPWDB1 BTPWDT0 BTPWDT1
+  BTPSAN BTPBN BTPTN BTPWNN PDRPREB PDRPRET SAENN RET RXP0 RXP1 RXP2 RXP3
+  YP0_0B YP0_0T YP0_1B YP0_1T YP0_2B YP0_2T YP0_3B YP0_3T VSSE VDDPE VDDCE
+  icache_tag_storeAPY4
XI2 ATRACK5B AX6NT AX6NT AX6NT ATRACK5B BS0NT BS0NT BS0NT BS1 BS1NT BS1NT
+  BS1NT BS1NT BS2 AX6NT AX6NT BSBN BSTN BTPCDBR BTPCDTR BTPSABR BTPSAR
+  BTPSATR BTPWDB0 BTPWDB1 BTPWDT0 BTPWDT1 BTPWNR DRPRENBR DRPRENTR GTPB GTPB
+  GTPDET GTPDET GTPDET GTPDET GTPDET GTPT LGWEN MBL_TERM MGDLET MGDLET MGDLET
+  MGDLET MGTPE MGTPET MGTPE MGDLET BTPBN BTPSAN BTPTN BTPWNN PDRPREB PDRPRET
+  PGB_TERM_0 PGT_TERM_0 SAENN RDT RET RRENB RRENB RRENT SAENR TIEHIGH MGDLET
+  YP0_0B YP0_0T YP0_1B YP0_1T YP0_2B YP0_2T YP0_3B YP0_3T VSSE VDDPE VDDCE
+  icache_tag_storeCK4
.ENDS icache_tag_storeLOCDECB0BT
****
.SUBCKT icache_tag_storeCDROWLB021T BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0_8 BL0_9 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7
+  BL0__8 BL0__9 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9
+  BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL2_0
+  BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6 BL2_7 BL2_8 BL2_9 BL2__0 BL2__1 BL2__2
+  BL2__3 BL2__4 BL2__5 BL2__6 BL2__7 BL2__8 BL2__9 BL3_0 BL3_1 BL3_2 BL3_3
+  BL3_4 BL3_5 BL3_6 BL3_7 BL3_8 BL3_9 BL3__0 BL3__1 BL3__2 BL3__3 BL3__4
+  BL3__5 BL3__6 BL3__7 BL3__8 BL3__9 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5
+  DR_6 DR_7 DR_8 DR_9 DR__0 DR__1 DR__2 DR__3 DR__4 DR__5 DR__6 DR__7 DR__8
+  DR__9 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW__0 DW__1 DW__2
+  DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5
+  GDL__6 GDL__7 GDL__8 GDL__9 TIELOW YP0_0N YP0_1N YP0_2N YP0_3N VSSE VDDPE
+  VDDCE
** icache_tag_storeCDROWLB021T: 524 flat devices **
XCD41 BL0_0 BL0__0 BL1_0 BL1__0 BL2_0 BL2__0 BL3_0 BL3__0 BTP DR_0 DRPREN
+  DR__0 DW_0 DW__0 GDL_0 GDL__0 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD410 BL0_9 BL0__9 BL1_9 BL1__9 BL2_9 BL2__9 BL3_9 BL3__9 BTP DR_9 DRPREN
+  DR__9 DW_9 DW__9 GDL_9 GDL__9 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD42 BL0_1 BL0__1 BL1_1 BL1__1 BL2_1 BL2__1 BL3_1 BL3__1 BTP DR_1 DRPREN
+  DR__1 DW_1 DW__1 GDL_1 GDL__1 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD43 BL0_2 BL0__2 BL1_2 BL1__2 BL2_2 BL2__2 BL3_2 BL3__2 BTP DR_2 DRPREN
+  DR__2 DW_2 DW__2 GDL_2 GDL__2 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD44 BL0_3 BL0__3 BL1_3 BL1__3 BL2_3 BL2__3 BL3_3 BL3__3 BTP DR_3 DRPREN
+  DR__3 DW_3 DW__3 GDL_3 GDL__3 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD45 BL0_4 BL0__4 BL1_4 BL1__4 BL2_4 BL2__4 BL3_4 BL3__4 BTP DR_4 DRPREN
+  DR__4 DW_4 DW__4 GDL_4 GDL__4 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD46 BL0_5 BL0__5 BL1_5 BL1__5 BL2_5 BL2__5 BL3_5 BL3__5 BTP DR_5 DRPREN
+  DR__5 DW_5 DW__5 GDL_5 GDL__5 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD47 BL0_6 BL0__6 BL1_6 BL1__6 BL2_6 BL2__6 BL3_6 BL3__6 BTP DR_6 DRPREN
+  DR__6 DW_6 DW__6 GDL_6 GDL__6 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD48 BL0_7 BL0__7 BL1_7 BL1__7 BL2_7 BL2__7 BL3_7 BL3__7 BTP DR_7 DRPREN
+  DR__7 DW_7 DW__7 GDL_7 GDL__7 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD49 BL0_8 BL0__8 BL1_8 BL1__8 BL2_8 BL2__8 BL3_8 BL3__8 BTP DR_8 DRPREN
+  DR__8 DW_8 DW__8 GDL_8 GDL__8 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XI40 BTP DRPREN VSSE TIELOW YP0_0N YP0_1N YP0_2N YP0_3N VSSE VDDPE VDDCE
+  icache_tag_storeCDEDGE4
.ENDS icache_tag_storeCDROWLB021T
****
.SUBCKT icache_tag_storeSA4 BTPB BTPSA BTPT BTPWN DRB DRB_ DRT DRT_ DW DW_ GDL
+  GDLB GDLB_ GDLT GDLT_ GDL_ SAEN VSSE VDDPE VDDCE
** icache_tag_storeSA4: 43 flat devices **
M0 VDDPE NET411 DW_ VDDCE PCH W=0.24U L=0.06U M=1 $name=/P18/P00
M1 VDDPE NET400 DW VDDCE PCH W=0.24U L=0.06U M=1 $name=/P20/P00
M10 DRT BTPTLB SD VDDCE PCH W=1.1U L=0.06U M=1 $name=/tdracc/P00
M11 SD_ SAENB SD VDDCE PCH W=0.3U L=0.06U M=1 $name=/P9/P00
M12 VDDPE SAENB SD_ VDDCE PCH W=0.3U L=0.06U M=1 $name=/P8/P00
M13 NET362 BTPSA VDDPE VDDCE PCH W=0.35U L=0.06U M=2 $name=/P63/P00
M14 DRT_ BTPTLB SD_ VDDCE PCH W=1.1U L=0.06U M=1 $name=/P5/P00
M15 DRB BTPBLB SD VDDCE PCH W=1.1U L=0.06U M=1 $name=/P4/P00
M16 DRB_ BTPBLB SD_ VDDCE PCH W=1.1U L=0.06U M=1 $name=/P3/P00
M17 SD SD_ VDDPE VDDCE PCH W=0.2U L=0.06U M=1 $name=/P13/P00
M18 SI_ SD_ NET362 VDDCE PCH W=0.5U L=0.06U M=1 $name=/P0/P00
M19 VDDPE GDL_ NET357 VDDCE PCH W=0.48U L=0.06U M=1 $name=/tpprea/P00
M2 VDDPE GDL NET348 VDDCE PCH W=0.48U L=0.06U M=1 $name=/P14/P00
M20 DW_ NET411 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N10/N00
M21 DW NET400 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N13/N00
M22 SE SAEN VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/N8/N00
M23 SE BTPSA VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/N9/N00
M24 NET411 GDL_ VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/tnpreb/N00
M25 NET411 BTPWN VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N0/N00
M26 NET400 GDL VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N7/N00
M27 SD_ SD SRC VSSE NCH W=1U L=0.17U M=4 $name=/tsdpd/N00
M28 VSSE BTPSA SI VSSE NCH W=0.13U L=0.06U M=1 $name=/tqbufn/N00
M29 VSSE SE SRC VSSE NCH W=1U L=0.17U M=4 $name=/tnpdsrc/N00
M3 NET348 BTPWN NET400 VDDCE PCH W=0.48U L=0.06U M=1 $name=/P15/P00
M30 GDL SI VSSE VSSE NCH W=1.4U L=0.06U M=2 $name=/tgdldrvn/N00
M31 NET400 BTPWN VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N4/N00
M32 VSSE SD SI VSSE NCH W=0.18U L=0.06U M=1 $name=/N67/N00
M33 GDL_ SI_ VSSE VSSE NCH W=1.4U L=0.06U M=2 $name=/N6/N00
M34 SRC SD_ SD VSSE NCH W=1U L=0.17U M=4 $name=/N5/N00
M35 SI_ SD_ VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N3/N00
M36 SI_ BTPSA VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N2/N00
M37 BTPTLB BTPT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tinvbtptlb/N00
M38 VDDPE BTPT BTPTLB VDDCE PCH W=0.21U L=0.06U M=1 $name=/tinvbtptlb/P00
M39 BTPBLB BTPB VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I21/N00
M4 VDDPE BTPSA NET354 VDDCE PCH W=0.7U L=0.06U M=1 $name=/P10/P00
M40 VDDPE BTPB BTPBLB VDDCE PCH W=0.21U L=0.06U M=1 $name=/I21/P00
M41 SAENB SAEN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I17/N00
M42 VDDPE SAEN SAENB VDDCE PCH W=0.15U L=0.06U M=1 $name=/I17/P00
M5 NET354 SAEN SE VDDCE PCH W=0.7U L=0.06U M=1 $name=/P7/P00
M6 NET357 BTPWN NET411 VDDCE PCH W=0.48U L=0.06U M=1 $name=/P1/P00
M7 VDDPE SD SD_ VDDCE PCH W=0.2U L=0.06U M=1 $name=/tsdpu/P00
M8 SI SD NET362 VDDCE PCH W=0.5U L=0.06U M=1 $name=/tqbufp/P00
M9 SD SAENB VDDPE VDDCE PCH W=0.3U L=0.06U M=1 $name=/tpresd/P00
.ENDS icache_tag_storeSA4
****
.SUBCKT icache_tag_storeBSAROW21RT BTPB BTPSA BTPT BTPWN DRB_0 DRB_1 DRB_2
+  DRB_3 DRB_4 DRB_5 DRB_6 DRB_7 DRB_8 DRB_9 DRB_10 DRB__0 DRB__1 DRB__2
+  DRB__3 DRB__4 DRB__5 DRB__6 DRB__7 DRB__8 DRB__9 DRB__10 DRT_0 DRT_1 DRT_2
+  DRT_3 DRT_4 DRT_5 DRT_6 DRT_7 DRT_8 DRT_9 DRT_10 DRT__0 DRT__1 DRT__2
+  DRT__3 DRT__4 DRT__5 DRT__6 DRT__7 DRT__8 DRT__9 DRT__10 DW_0 DW_1 DW_2
+  DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW__0 DW__1 DW__2 DW__3 DW__4
+  DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4
+  GDLB_5 GDLB_6 GDLB_7 GDLB_8 GDLB_9 GDLB_10 GDLB__0 GDLB__1 GDLB__2 GDLB__3
+  GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8 GDLB__9 GDLB__10 GDLT_0 GDLT_1
+  GDLT_2 GDLT_3 GDLT_4 GDLT_5 GDLT_6 GDLT_7 GDLT_8 GDLT_9 GDLT_10 GDLT__0
+  GDLT__1 GDLT__2 GDLT__3 GDLT__4 GDLT__5 GDLT__6 GDLT__7 GDLT__8 GDLT__9
+  GDLT__10 SAEN VSSE VDDPE VDDCE
** icache_tag_storeBSAROW21RT: 473 flat devices **
XSA41 BTPB BTPSA BTPT BTPWN DRB_0 DRB__0 DRT_0 DRT__0 DW_0 DW__0 GDLB_0 GDLB_0
+  GDLB__0 GDLT_0 GDLT__0 GDLB__0 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA410 BTPB BTPSA BTPT BTPWN DRB_9 DRB__9 DRT_9 DRT__9 DW_9 DW__9 GDLB_9
+  GDLB_9 GDLB__9 GDLT_9 GDLT__9 GDLB__9 SAEN VSSE VDDPE VDDCE
+  icache_tag_storeSA4
XSA411 BTPB BTPSA BTPT BTPWN DRB_10 DRB__10 DRT_10 DRT__10 DW_10 DW__10
+  GDLB_10 GDLB_10 GDLB__10 GDLT_10 GDLT__10 GDLB__10 SAEN VSSE VDDPE VDDCE
+  icache_tag_storeSA4
XSA42 BTPB BTPSA BTPT BTPWN DRB_1 DRB__1 DRT_1 DRT__1 DW_1 DW__1 GDLB_1 GDLB_1
+  GDLB__1 GDLT_1 GDLT__1 GDLB__1 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA43 BTPB BTPSA BTPT BTPWN DRB_2 DRB__2 DRT_2 DRT__2 DW_2 DW__2 GDLB_2 GDLB_2
+  GDLB__2 GDLT_2 GDLT__2 GDLB__2 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA44 BTPB BTPSA BTPT BTPWN DRB_3 DRB__3 DRT_3 DRT__3 DW_3 DW__3 GDLB_3 GDLB_3
+  GDLB__3 GDLT_3 GDLT__3 GDLB__3 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA45 BTPB BTPSA BTPT BTPWN DRB_4 DRB__4 DRT_4 DRT__4 DW_4 DW__4 GDLB_4 GDLB_4
+  GDLB__4 GDLT_4 GDLT__4 GDLB__4 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA46 BTPB BTPSA BTPT BTPWN DRB_5 DRB__5 DRT_5 DRT__5 DW_5 DW__5 GDLB_5 GDLB_5
+  GDLB__5 GDLT_5 GDLT__5 GDLB__5 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA47 BTPB BTPSA BTPT BTPWN DRB_6 DRB__6 DRT_6 DRT__6 DW_6 DW__6 GDLB_6 GDLB_6
+  GDLB__6 GDLT_6 GDLT__6 GDLB__6 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA48 BTPB BTPSA BTPT BTPWN DRB_7 DRB__7 DRT_7 DRT__7 DW_7 DW__7 GDLB_7 GDLB_7
+  GDLB__7 GDLT_7 GDLT__7 GDLB__7 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA49 BTPB BTPSA BTPT BTPWN DRB_8 DRB__8 DRT_8 DRT__8 DW_8 DW__8 GDLB_8 GDLB_8
+  GDLB__8 GDLT_8 GDLT__8 GDLB__8 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
.ENDS icache_tag_storeBSAROW21RT
****
.SUBCKT icache_tag_storeBSAROW21LT BTPB BTPSA BTPT BTPWN DRB_0 DRB_1 DRB_2
+  DRB_3 DRB_4 DRB_5 DRB_6 DRB_7 DRB_8 DRB_9 DRB__0 DRB__1 DRB__2 DRB__3
+  DRB__4 DRB__5 DRB__6 DRB__7 DRB__8 DRB__9 DRT_0 DRT_1 DRT_2 DRT_3 DRT_4
+  DRT_5 DRT_6 DRT_7 DRT_8 DRT_9 DRT__0 DRT__1 DRT__2 DRT__3 DRT__4 DRT__5
+  DRT__6 DRT__7 DRT__8 DRT__9 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8
+  DW_9 DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 GDLB_0
+  GDLB_1 GDLB_2 GDLB_3 GDLB_4 GDLB_5 GDLB_6 GDLB_7 GDLB_8 GDLB_9 GDLB__0
+  GDLB__1 GDLB__2 GDLB__3 GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8 GDLB__9
+  GDLT_0 GDLT_1 GDLT_2 GDLT_3 GDLT_4 GDLT_5 GDLT_6 GDLT_7 GDLT_8 GDLT_9
+  GDLT__0 GDLT__1 GDLT__2 GDLT__3 GDLT__4 GDLT__5 GDLT__6 GDLT__7 GDLT__8
+  GDLT__9 SAEN VSSE VDDPE VDDCE
** icache_tag_storeBSAROW21LT: 430 flat devices **
XSA41 BTPB BTPSA BTPT BTPWN DRB_0 DRB__0 DRT_0 DRT__0 DW_0 DW__0 GDLB_0 GDLB_0
+  GDLB__0 GDLT_0 GDLT__0 GDLB__0 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA410 BTPB BTPSA BTPT BTPWN DRB_9 DRB__9 DRT_9 DRT__9 DW_9 DW__9 GDLB_9
+  GDLB_9 GDLB__9 GDLT_9 GDLT__9 GDLB__9 SAEN VSSE VDDPE VDDCE
+  icache_tag_storeSA4
XSA42 BTPB BTPSA BTPT BTPWN DRB_1 DRB__1 DRT_1 DRT__1 DW_1 DW__1 GDLB_1 GDLB_1
+  GDLB__1 GDLT_1 GDLT__1 GDLB__1 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA43 BTPB BTPSA BTPT BTPWN DRB_2 DRB__2 DRT_2 DRT__2 DW_2 DW__2 GDLB_2 GDLB_2
+  GDLB__2 GDLT_2 GDLT__2 GDLB__2 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA44 BTPB BTPSA BTPT BTPWN DRB_3 DRB__3 DRT_3 DRT__3 DW_3 DW__3 GDLB_3 GDLB_3
+  GDLB__3 GDLT_3 GDLT__3 GDLB__3 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA45 BTPB BTPSA BTPT BTPWN DRB_4 DRB__4 DRT_4 DRT__4 DW_4 DW__4 GDLB_4 GDLB_4
+  GDLB__4 GDLT_4 GDLT__4 GDLB__4 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA46 BTPB BTPSA BTPT BTPWN DRB_5 DRB__5 DRT_5 DRT__5 DW_5 DW__5 GDLB_5 GDLB_5
+  GDLB__5 GDLT_5 GDLT__5 GDLB__5 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA47 BTPB BTPSA BTPT BTPWN DRB_6 DRB__6 DRT_6 DRT__6 DW_6 DW__6 GDLB_6 GDLB_6
+  GDLB__6 GDLT_6 GDLT__6 GDLB__6 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA48 BTPB BTPSA BTPT BTPWN DRB_7 DRB__7 DRT_7 DRT__7 DW_7 DW__7 GDLB_7 GDLB_7
+  GDLB__7 GDLT_7 GDLT__7 GDLB__7 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
XSA49 BTPB BTPSA BTPT BTPWN DRB_8 DRB__8 DRT_8 DRT__8 DW_8 DW__8 GDLB_8 GDLB_8
+  GDLB__8 GDLT_8 GDLT__8 GDLB__8 SAEN VSSE VDDPE VDDCE icache_tag_storeSA4
.ENDS icache_tag_storeBSAROW21LT
****
.SUBCKT icache_tag_storeCDROWLT021T BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0_8 BL0_9 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7
+  BL0__8 BL0__9 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9
+  BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL2_0
+  BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6 BL2_7 BL2_8 BL2_9 BL2__0 BL2__1 BL2__2
+  BL2__3 BL2__4 BL2__5 BL2__6 BL2__7 BL2__8 BL2__9 BL3_0 BL3_1 BL3_2 BL3_3
+  BL3_4 BL3_5 BL3_6 BL3_7 BL3_8 BL3_9 BL3__0 BL3__1 BL3__2 BL3__3 BL3__4
+  BL3__5 BL3__6 BL3__7 BL3__8 BL3__9 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5
+  DR_6 DR_7 DR_8 DR_9 DR__0 DR__1 DR__2 DR__3 DR__4 DR__5 DR__6 DR__7 DR__8
+  DR__9 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW__0 DW__1 DW__2
+  DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5
+  GDL__6 GDL__7 GDL__8 GDL__9 TIELOW YP0_0N YP0_1N YP0_2N YP0_3N VSSE VDDPE
+  VDDCE
** icache_tag_storeCDROWLT021T: 524 flat devices **
XCD41 BL0_0 BL0__0 BL1_0 BL1__0 BL2_0 BL2__0 BL3_0 BL3__0 BTP DR_0 DRPREN
+  DR__0 DW_0 DW__0 GDL_0 GDL__0 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD410 BL0_9 BL0__9 BL1_9 BL1__9 BL2_9 BL2__9 BL3_9 BL3__9 BTP DR_9 DRPREN
+  DR__9 DW_9 DW__9 GDL_9 GDL__9 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD42 BL0_1 BL0__1 BL1_1 BL1__1 BL2_1 BL2__1 BL3_1 BL3__1 BTP DR_1 DRPREN
+  DR__1 DW_1 DW__1 GDL_1 GDL__1 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD43 BL0_2 BL0__2 BL1_2 BL1__2 BL2_2 BL2__2 BL3_2 BL3__2 BTP DR_2 DRPREN
+  DR__2 DW_2 DW__2 GDL_2 GDL__2 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD44 BL0_3 BL0__3 BL1_3 BL1__3 BL2_3 BL2__3 BL3_3 BL3__3 BTP DR_3 DRPREN
+  DR__3 DW_3 DW__3 GDL_3 GDL__3 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD45 BL0_4 BL0__4 BL1_4 BL1__4 BL2_4 BL2__4 BL3_4 BL3__4 BTP DR_4 DRPREN
+  DR__4 DW_4 DW__4 GDL_4 GDL__4 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD46 BL0_5 BL0__5 BL1_5 BL1__5 BL2_5 BL2__5 BL3_5 BL3__5 BTP DR_5 DRPREN
+  DR__5 DW_5 DW__5 GDL_5 GDL__5 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD47 BL0_6 BL0__6 BL1_6 BL1__6 BL2_6 BL2__6 BL3_6 BL3__6 BTP DR_6 DRPREN
+  DR__6 DW_6 DW__6 GDL_6 GDL__6 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD48 BL0_7 BL0__7 BL1_7 BL1__7 BL2_7 BL2__7 BL3_7 BL3__7 BTP DR_7 DRPREN
+  DR__7 DW_7 DW__7 GDL_7 GDL__7 YP0_3N YP0_0N YP0_1N YP0_2N YP0_3N YP0_2N
+  YP0_1N YP0_0N VSSE VDDPE VDDCE icache_tag_storeCD4
XCD49 BL0_8 BL0__8 BL1_8 BL1__8 BL2_8 BL2__8 BL3_8 BL3__8 BTP DR_8 DRPREN
+  DR__8 DW_8 DW__8 GDL_8 GDL__8 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_1N
+  YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCD4
XI40 BTP DRPREN VSSE TIELOW YP0_0N YP0_1N YP0_2N YP0_3N VSSE VDDPE VDDCE
+  icache_tag_storeCDEDGE4
.ENDS icache_tag_storeCDROWLT021T
****
.SUBCKT icache_tag_storeCHB0_21M4BT ATRACK0B ATRACK0T ATRACK1B ATRACK1T
+  ATRACK2B ATRACK2T ATRACK3B ATRACK3T ATRACK4B ATRACK4T ATRACK5B ATRACK5T
+  AX6NT AY0NB AY0NT AY1NB AY1NT AY2NB AY2NT BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15
+  BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25
+  BL0_26 BL0_27 BL0_28 BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35
+  BL0_36 BL0_37 BL0_38 BL0_39 BL0_40 BL0_41 BL0__0 BL0__1 BL0__2 BL0__3
+  BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13
+  BL0__14 BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22
+  BL0__23 BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL0__31
+  BL0__32 BL0__33 BL0__34 BL0__35 BL0__36 BL0__37 BL0__38 BL0__39 BL0__40
+  BL0__41 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10
+  BL1_11 BL1_12 BL1_13 BL1_14 BL1_15 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20
+  BL1_21 BL1_22 BL1_23 BL1_24 BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30
+  BL1_31 BL1_32 BL1_33 BL1_34 BL1_35 BL1_36 BL1_37 BL1_38 BL1_39 BL1_40
+  BL1_41 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8
+  BL1__9 BL1__10 BL1__11 BL1__12 BL1__13 BL1__14 BL1__15 BL1__16 BL1__17
+  BL1__18 BL1__19 BL1__20 BL1__21 BL1__22 BL1__23 BL1__24 BL1__25 BL1__26
+  BL1__27 BL1__28 BL1__29 BL1__30 BL1__31 BL1__32 BL1__33 BL1__34 BL1__35
+  BL1__36 BL1__37 BL1__38 BL1__39 BL1__40 BL1__41 BL2_0 BL2_1 BL2_2 BL2_3
+  BL2_4 BL2_5 BL2_6 BL2_7 BL2_8 BL2_9 BL2_10 BL2_11 BL2_12 BL2_13 BL2_14
+  BL2_15 BL2_16 BL2_17 BL2_18 BL2_19 BL2_20 BL2_21 BL2_22 BL2_23 BL2_24
+  BL2_25 BL2_26 BL2_27 BL2_28 BL2_29 BL2_30 BL2_31 BL2_32 BL2_33 BL2_34
+  BL2_35 BL2_36 BL2_37 BL2_38 BL2_39 BL2_40 BL2_41 BL2__0 BL2__1 BL2__2
+  BL2__3 BL2__4 BL2__5 BL2__6 BL2__7 BL2__8 BL2__9 BL2__10 BL2__11 BL2__12
+  BL2__13 BL2__14 BL2__15 BL2__16 BL2__17 BL2__18 BL2__19 BL2__20 BL2__21
+  BL2__22 BL2__23 BL2__24 BL2__25 BL2__26 BL2__27 BL2__28 BL2__29 BL2__30
+  BL2__31 BL2__32 BL2__33 BL2__34 BL2__35 BL2__36 BL2__37 BL2__38 BL2__39
+  BL2__40 BL2__41 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6 BL3_7 BL3_8 BL3_9
+  BL3_10 BL3_11 BL3_12 BL3_13 BL3_14 BL3_15 BL3_16 BL3_17 BL3_18 BL3_19
+  BL3_20 BL3_21 BL3_22 BL3_23 BL3_24 BL3_25 BL3_26 BL3_27 BL3_28 BL3_29
+  BL3_30 BL3_31 BL3_32 BL3_33 BL3_34 BL3_35 BL3_36 BL3_37 BL3_38 BL3_39
+  BL3_40 BL3_41 BL3__0 BL3__1 BL3__2 BL3__3 BL3__4 BL3__5 BL3__6 BL3__7
+  BL3__8 BL3__9 BL3__10 BL3__11 BL3__12 BL3__13 BL3__14 BL3__15 BL3__16
+  BL3__17 BL3__18 BL3__19 BL3__20 BL3__21 BL3__22 BL3__23 BL3__24 BL3__25
+  BL3__26 BL3__27 BL3__28 BL3__29 BL3__30 BL3__31 BL3__32 BL3__33 BL3__34
+  BL3__35 BL3__36 BL3__37 BL3__38 BL3__39 BL3__40 BL3__41 BS0NT BS1NT
+  BTPB2_TERM BTPB3_TERM BTPT2_TERM BTPT3_TERM BTPWDB0 BTPWDB1 BTPWDT0 BTPWDT1
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9
+  GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 GDL__16 GDL__17 GDL__18
+  GDL__19 GDL__20 GDL__21 GDL__22 GDL__23 GDL__24 GDL__25 GDL__26 GDL__27
+  GDL__28 GDL__29 GDL__30 GDL__31 GDL__32 GDL__33 GDL__34 GDL__35 GDL__36
+  GDL__37 GDL__38 GDL__39 GDL__40 GDL__41 GTPB GTPDET GTPT LGWEN MBL_TERM
+  MGDLET MGTPE MGTPET RDT RET RRENB RRENT RXP0 RXP1 RXP2 RXP3 TIEHIGHB
+  TIEHIGHT TIELOWB TIELOWT TIELOW_0 TIELOW_1 TIELOW_2 TIELOW_3 XP0 XP0_ XP1
+  XP1_ XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5 XP5_ VSSE VDDPE VDDCE
** icache_tag_storeCHB0_21M4BT: 3592 flat devices **
XLEFTBOTCDROW BL0_30 BL0_29 BL0_28 BL0_27 BL0_26 BL0_25 BL0_24 BL0_23 BL0_22
+  BL0_21 BL0__30 BL0__29 BL0__28 BL0__27 BL0__26 BL0__25 BL0__24 BL0__23
+  BL0__22 BL0__21 BL1_30 BL1_29 BL1_28 BL1_27 BL1_26 BL1_25 BL1_24 BL1_23
+  BL1_22 BL1_21 BL1__30 BL1__29 BL1__28 BL1__27 BL1__26 BL1__25 BL1__24
+  BL1__23 BL1__22 BL1__21 BL2_30 BL2_29 BL2_28 BL2_27 BL2_26 BL2_25 BL2_24
+  BL2_23 BL2_22 BL2_21 BL2__30 BL2__29 BL2__28 BL2__27 BL2__26 BL2__25
+  BL2__24 BL2__23 BL2__22 BL2__21 BL3_30 BL3_29 BL3_28 BL3_27 BL3_26 BL3_25
+  BL3_24 BL3_23 BL3_22 BL3_21 BL3__30 BL3__29 BL3__28 BL3__27 BL3__26 BL3__25
+  BL3__24 BL3__23 BL3__22 BL3__21 BTPCDB DRPRENB DR_0_198 DR_1_184 DR_2_182
+  DR_3_168 DR_4_166 DR_5_152 DR_6_150 DR_7_136 DR_8_134 DR_9_120 DR__0_196
+  DR__1_186 DR__2_180 DR__3_170 DR__4_164 DR__5_154 DR__6_148 DR__7_138
+  DR__8_132 DR__9_122 DW_0_194 DW_1_188 DW_2_178 DW_3_172 DW_4_162 DW_5_156
+  DW_6_146 DW_7_140 DW_8_130 DW_9_124 DW__0_192 DW__1_190 DW__2_176 DW__3_174
+  DW__4_160 DW__5_158 DW__6_144 DW__7_142 DW__8_128 DW__9_126 GDL_30 GDL_29
+  GDL_28 GDL_27 GDL_26 GDL_25 GDL_24 GDL_23 GDL_22 GDL_21 GDL__30 GDL__29
+  GDL__28 GDL__27 GDL__26 GDL__25 GDL__24 GDL__23 GDL__22 GDL__21 TIELOW_2
+  YP0_0N YP0_1N YP0_2N YP0_3N VSSE VDDPE VDDCE icache_tag_storeCDROWLB021T
XLEFTSAROW BTPB BTPSA BTPT BTPWN DR_0_198 DR_1_184 DR_2_182 DR_3_168 DR_4_166
+  DR_5_152 DR_6_150 DR_7_136 DR_8_134 DR_9_120 DR__0_196 DR__1_186 DR__2_180
+  DR__3_170 DR__4_164 DR__5_154 DR__6_148 DR__7_138 DR__8_132 DR__9_122 DRT_0
+  DRT_1 DRT_2 DRT_3 DRT_4 DRT_5 DRT_6 DRT_7 DRT_8 DRT_9 DRT__0 DRT__1 DRT__2
+  DRT__3 DRT__4 DRT__5 DRT__6 DRT__7 DRT__8 DRT__9 DW_0_194 DW_1_188 DW_2_178
+  DW_3_172 DW_4_162 DW_5_156 DW_6_146 DW_7_140 DW_8_130 DW_9_124 DW__0_192
+  DW__1_190 DW__2_176 DW__3_174 DW__4_160 DW__5_158 DW__6_144 DW__7_142
+  DW__8_128 DW__9_126 GDL_30 GDL_29 GDL_28 GDL_27 GDL_26 GDL_25 GDL_24 GDL_23
+  GDL_22 GDL_21 GDL__30 GDL__29 GDL__28 GDL__27 GDL__26 GDL__25 GDL__24
+  GDL__23 GDL__22 GDL__21 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5 GDL_4 GDL_3 GDL_2
+  GDL_1 GDL_0 GDL__9 GDL__8 GDL__7 GDL__6 GDL__5 GDL__4 GDL__3 GDL__2 GDL__1
+  GDL__0 SAEN VSSE VDDPE VDDCE icache_tag_storeBSAROW21LT
XLEFTTOPCDROW BL0_9 BL0_8 BL0_7 BL0_6 BL0_5 BL0_4 BL0_3 BL0_2 BL0_1 BL0_0
+  BL0__9 BL0__8 BL0__7 BL0__6 BL0__5 BL0__4 BL0__3 BL0__2 BL0__1 BL0__0 BL1_9
+  BL1_8 BL1_7 BL1_6 BL1_5 BL1_4 BL1_3 BL1_2 BL1_1 BL1_0 BL1__9 BL1__8 BL1__7
+  BL1__6 BL1__5 BL1__4 BL1__3 BL1__2 BL1__1 BL1__0 BL2_9 BL2_8 BL2_7 BL2_6
+  BL2_5 BL2_4 BL2_3 BL2_2 BL2_1 BL2_0 BL2__9 BL2__8 BL2__7 BL2__6 BL2__5
+  BL2__4 BL2__3 BL2__2 BL2__1 BL2__0 BL3_9 BL3_8 BL3_7 BL3_6 BL3_5 BL3_4
+  BL3_3 BL3_2 BL3_1 BL3_0 BL3__9 BL3__8 BL3__7 BL3__6 BL3__5 BL3__4 BL3__3
+  BL3__2 BL3__1 BL3__0 BTPCDT DRPRENT DRT_0 DRT_1 DRT_2 DRT_3 DRT_4 DRT_5
+  DRT_6 DRT_7 DRT_8 DRT_9 DRT__0 DRT__1 DRT__2 DRT__3 DRT__4 DRT__5 DRT__6
+  DRT__7 DRT__8 DRT__9 DW_0_194 DW_1_188 DW_2_178 DW_3_172 DW_4_162 DW_5_156
+  DW_6_146 DW_7_140 DW_8_130 DW_9_124 DW__0_192 DW__1_190 DW__2_176 DW__3_174
+  DW__4_160 DW__5_158 DW__6_144 DW__7_142 DW__8_128 DW__9_126 GDL_9 GDL_8
+  GDL_7 GDL_6 GDL_5 GDL_4 GDL_3 GDL_2 GDL_1 GDL_0 GDL__9 GDL__8 GDL__7 GDL__6
+  GDL__5 GDL__4 GDL__3 GDL__2 GDL__1 GDL__0 TIELOW_0 YP0_0N_96 YP0_1N_98
+  YP0_2N_100 YP0_3N_102 VSSE VDDPE VDDCE icache_tag_storeCDROWLT021T
XLOCAL_DEC ATRACK0B ATRACK0T ATRACK1B ATRACK1T ATRACK2B ATRACK2T ATRACK3B
+  ATRACK3T ATRACK4B ATRACK4T ATRACK5B ATRACK5T AX6NT AY0NB AY0NT AY1NB AY1NT
+  AY2NB AY2NT BS0NT BS1NT BTPB BTPB2_TERM BTPB3_TERM BTPCDB BTP BTPCDT BTP_94
+  BTPSA BTPSABR BTPSAR BTPSATR BTPT BTPT2_TERM BTPT3_TERM BTPWDB0 BTPWDB1
+  BTPWDT0 BTPWDT1 BTPWN BTPWNR DRPRENB DRPREN DRPRENT DRPREN_104 GTPB GTPDET
+  GTPT LGWEN MBL_TERM MGDLET MGTPE MGTPET VSSE VSSE VSSE VSSE RDT RET RRENB
+  RRENT RXP0 RXP1 RXP2 RXP3 SAEN SAENR TIEHIGHB TIEHIGHT TIELOWB TIELOWT XP0
+  XP0_ XP1 XP1_ XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5 XP5_ YP0_0N YP0_0N_96 YP0_1N
+  YP0_1N_98 YP0_2N YP0_2N_100 YP0_3N YP0_3N_102 VSSE VDDPE VDDCE
+  icache_tag_storeLOCDECB0BT
XRIGHTBOTCDROW BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36 BL0_37 BL0_38 BL0_39
+  BL0_40 BL0_41 BL0__31 BL0__32 BL0__33 BL0__34 BL0__35 BL0__36 BL0__37
+  BL0__38 BL0__39 BL0__40 BL0__41 BL1_31 BL1_32 BL1_33 BL1_34 BL1_35 BL1_36
+  BL1_37 BL1_38 BL1_39 BL1_40 BL1_41 BL1__31 BL1__32 BL1__33 BL1__34 BL1__35
+  BL1__36 BL1__37 BL1__38 BL1__39 BL1__40 BL1__41 BL2_31 BL2_32 BL2_33 BL2_34
+  BL2_35 BL2_36 BL2_37 BL2_38 BL2_39 BL2_40 BL2_41 BL2__31 BL2__32 BL2__33
+  BL2__34 BL2__35 BL2__36 BL2__37 BL2__38 BL2__39 BL2__40 BL2__41 BL3_31
+  BL3_32 BL3_33 BL3_34 BL3_35 BL3_36 BL3_37 BL3_38 BL3_39 BL3_40 BL3_41
+  BL3__31 BL3__32 BL3__33 BL3__34 BL3__35 BL3__36 BL3__37 BL3__38 BL3__39
+  BL3__40 BL3__41 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5 DR_6 DR_7 DR_8
+  DR_9 DR_10 DR__0 DR__1 DR__2 DR__3 DR__4 DR__5 DR__6 DR__7 DR__8 DR__9
+  DR__10 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW__0 DW__1
+  DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 GDL_31 GDL_32 GDL_33
+  GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL__31 GDL__32
+  GDL__33 GDL__34 GDL__35 GDL__36 GDL__37 GDL__38 GDL__39 GDL__40 GDL__41
+  TIELOW_3 YP0_0N YP0_1N YP0_2N YP0_3N VSSE VDDPE VDDCE
+  icache_tag_storeCDROWRB021T
XRIGHTBOTSAROW BTPSABR BTPSAR BTPSATR BTPWNR DR_0 DR_1 DR_2 DR_3 DR_4 DR_5
+  DR_6 DR_7 DR_8 DR_9 DR_10 DR__0 DR__1 DR__2 DR__3 DR__4 DR__5 DR__6 DR__7
+  DR__8 DR__9 DR__10 DR_0_92 DR_1_86 DR_2_84 DR_3_78 DR_4_76 DR_5_70 DR_6_68
+  DR_7_62 DR_8_60 DR_9_54 DR_10_52 DR__0_90 DR__1_88 DR__2_82 DR__3_80
+  DR__4_74 DR__5_72 DR__6_66 DR__7_64 DR__8_58 DR__9_56 DR__10_50 DW_0 DW_1
+  DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW__0 DW__1 DW__2 DW__3 DW__4
+  DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35
+  GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL__31 GDL__32 GDL__33 GDL__34
+  GDL__35 GDL__36 GDL__37 GDL__38 GDL__39 GDL__40 GDL__41 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL__10
+  GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 GDL__16 GDL__17 GDL__18 GDL__19
+  GDL__20 SAENR VSSE VDDPE VDDCE icache_tag_storeBSAROW21RT
XRIGHTTOPCDROW BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16 BL0_17 BL0_18
+  BL0_19 BL0_20 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14 BL0__15 BL0__16
+  BL0__17 BL0__18 BL0__19 BL0__20 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15
+  BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1__10 BL1__11 BL1__12 BL1__13 BL1__14
+  BL1__15 BL1__16 BL1__17 BL1__18 BL1__19 BL1__20 BL2_10 BL2_11 BL2_12 BL2_13
+  BL2_14 BL2_15 BL2_16 BL2_17 BL2_18 BL2_19 BL2_20 BL2__10 BL2__11 BL2__12
+  BL2__13 BL2__14 BL2__15 BL2__16 BL2__17 BL2__18 BL2__19 BL2__20 BL3_10
+  BL3_11 BL3_12 BL3_13 BL3_14 BL3_15 BL3_16 BL3_17 BL3_18 BL3_19 BL3_20
+  BL3__10 BL3__11 BL3__12 BL3__13 BL3__14 BL3__15 BL3__16 BL3__17 BL3__18
+  BL3__19 BL3__20 BTP_94 DRPREN_104 DR_0_92 DR_1_86 DR_2_84 DR_3_78 DR_4_76
+  DR_5_70 DR_6_68 DR_7_62 DR_8_60 DR_9_54 DR_10_52 DR__0_90 DR__1_88 DR__2_82
+  DR__3_80 DR__4_74 DR__5_72 DR__6_66 DR__7_64 DR__8_58 DR__9_56 DR__10_50
+  DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW__0 DW__1 DW__2
+  DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 GDL_10 GDL_11 GDL_12
+  GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL__10 GDL__11
+  GDL__12 GDL__13 GDL__14 GDL__15 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20
+  TIELOW_1 YP0_0N_96 YP0_1N_98 YP0_2N_100 YP0_3N_102 VSSE VDDPE VDDCE
+  icache_tag_storeCDROWRT021T
.ENDS icache_tag_storeCHB0_21M4BT
****
.SUBCKT icache_tag_storeCC BL BL_ CORED CORED_ GDL PG0 WL VSSE VDDPE VDDCE
** icache_tag_storeCC: 6 flat devices **
M0 CORED CORED_ VDDCE VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M1 VDDCE CORED CORED_ VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M2 CORED_ CORED VSSE VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M3 VSSE CORED_ CORED VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M4 BL WL CORED VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M5 CORED_ WL BL_ VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS icache_tag_storeCC
****
.SUBCKT icache_tag_storeWRAPPED_CC BL BL_ GDL PG0 WL VSSE VDDPE VDDCE
** icache_tag_storeWRAPPED_CC: 6 flat devices **
XI0 BL BL_ CORED CORED_ GDL PG0 WL VSSE VDDPE VDDCE icache_tag_storeCC
.ENDS icache_tag_storeWRAPPED_CC
****
.SUBCKT icache_tag_storeCCEDGE_CCMBL BL CCMBL DIFF GDL NDIFF PDIFF PG0 TL0 WL
+  VSSE VDDPE VDDCE
** icache_tag_storeCCEDGE_CCMBL: 6 flat devices **
M0 NET41 NET49 VSSE VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M1 NDIFF NET41 NET49 VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M2 NET41 WL DIFF VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
M3 CCMBL TL0 NET49 VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M4 PDIFF NET49 NET41 VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M5 NET49 NET41 VDDCE VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
.ENDS icache_tag_storeCCEDGE_CCMBL
****
.SUBCKT icache_tag_storeCC_ROW40LO BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 CCMBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25
+  GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35
+  GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3
+  PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14
+  PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24
+  PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34
+  PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL VSSE VDDPE
+  VDDCE
** icache_tag_storeCC_ROW40LO: 246 flat devices **
XCC1 BL_1 BL__0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC10 BL_10 BL__9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC11 BL_11 BL__10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC12 BL_12 BL__11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC13 BL_13 BL__12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC14 BL_14 BL__13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC15 BL_15 BL__14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC16 BL_16 BL__15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC17 BL_17 BL__16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC18 BL_18 BL__17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC19 BL_19 BL__18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC2 BL_2 BL__1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC20 BL_20 BL__19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC21 BL_21 BL__20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC22 BL_22 BL__21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC23 BL_23 BL__22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC24 BL_24 BL__23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC25 BL_25 BL__24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC26 BL_26 BL__25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC27 BL_27 BL__26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC28 BL_28 BL__27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC29 BL_29 BL__28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC3 BL_3 BL__2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC30 BL_30 BL__29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC31 BL_31 BL__30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC32 BL_32 BL__31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC33 BL_33 BL__32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC34 BL_34 BL__33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC35 BL_35 BL__34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC36 BL_36 BL__35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC37 BL_37 BL__36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC38 BL_38 BL__37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC39 BL_39 BL__38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC4 BL_4 BL__3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC40 BL_40 BL__39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC5 BL_5 BL__4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC6 BL_6 BL__5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC7 BL_7 BL__6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC8 BL_8 BL__7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC9 BL_9 BL__8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCEDGE_CCMBL
.ENDS icache_tag_storeCC_ROW40LO
****
.SUBCKT icache_tag_storeCC_ROW40LE BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 CCMBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25
+  GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35
+  GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3
+  PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14
+  PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24
+  PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34
+  PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL VSSE VDDPE
+  VDDCE
** icache_tag_storeCC_ROW40LE: 246 flat devices **
XCC1 BL_1 BL__0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC10 BL_10 BL__9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC11 BL_11 BL__10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC12 BL_12 BL__11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC13 BL_13 BL__12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC14 BL_14 BL__13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC15 BL_15 BL__14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC16 BL_16 BL__15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC17 BL_17 BL__16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC18 BL_18 BL__17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC19 BL_19 BL__18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC2 BL_2 BL__1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC20 BL_20 BL__19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC21 BL_21 BL__20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC22 BL_22 BL__21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC23 BL_23 BL__22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC24 BL_24 BL__23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC25 BL_25 BL__24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC26 BL_26 BL__25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC27 BL_27 BL__26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC28 BL_28 BL__27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC29 BL_29 BL__28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC3 BL_3 BL__2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC30 BL_30 BL__29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC31 BL_31 BL__30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC32 BL_32 BL__31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC33 BL_33 BL__32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC34 BL_34 BL__33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC35 BL_35 BL__34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC36 BL_36 BL__35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC37 BL_37 BL__36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC38 BL_38 BL__37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC39 BL_39 BL__38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC4 BL_4 BL__3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC40 BL_40 BL__39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC5 BL_5 BL__4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC6 BL_6 BL__5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC7 BL_7 BL__6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC8 BL_8 BL__7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC9 BL_9 BL__8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCEDGE_CCMBL
.ENDS icache_tag_storeCC_ROW40LE
****
.SUBCKT icache_tag_storeFLMW BL BL_ DIFF1 DIFF2 GDL PG0 WL0 WL1 VSSE VDDPE
+  VDDCE
** icache_tag_storeFLMW: 6 flat devices **
M0 VSSE CORED_ CORED VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M1 CORED_ CORED VSSE VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M2 VDDCE CORED CORED_ VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M3 CORED CORED_ VDDCE VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M4 DIFF1 WL0 CORED VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M5 CORED_ WL1 DIFF2 VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS icache_tag_storeFLMW
****
.SUBCKT icache_tag_storeCCW BL BL_ CORED CORED_ DIFF1 DIFF2 GDL PG0 WL VSSE
+  VDDPE VDDCE
** icache_tag_storeCCW: 6 flat devices **
M0 CORED CORED_ VDDCE VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M1 VDDCE CORED CORED_ VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M2 CORED_ CORED VSSE VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M3 VSSE CORED_ CORED VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M4 DIFF1 WL CORED VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M5 CORED_ WL DIFF2 VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS icache_tag_storeCCW
****
.SUBCKT icache_tag_storeMWL_CC BL BL_ DIFF1 DIFF2 GDL PG0 WL VSSE VDDPE VDDCE
** icache_tag_storeMWL_CC: 6 flat devices **
XI0 BL BL_ CORED CORED_ DIFF1 DIFF2 GDL PG0 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCW
.ENDS icache_tag_storeMWL_CC
****
.SUBCKT icache_tag_storeMWL_ROW40LO BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 CCMBL DIFF DIFF1_0 DIFF1_1 DIFF1_2
+  DIFF1_3 DIFF1_4 DIFF1_5 DIFF1_6 DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11
+  DIFF1_12 DIFF1_13 DIFF1_14 DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19
+  DIFF1_20 DIFF1_21 DIFF1_22 DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27
+  DIFF1_28 DIFF1_29 DIFF1_30 DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35
+  DIFF1_36 DIFF1_37 DIFF1_38 DIFF1_39 DIFF2_0 DIFF2_1 DIFF2_2 DIFF2_3 DIFF2_4
+  DIFF2_5 DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10 DIFF2_11 DIFF2_12 DIFF2_13
+  DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18 DIFF2_19 DIFF2_20 DIFF2_21
+  DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26 DIFF2_27 DIFF2_28 DIFF2_29
+  DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34 DIFF2_35 DIFF2_36 DIFF2_37
+  DIFF2_38 DIFF2_39 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8
+  PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 TL0_0 TL0_1 TL1 WL1 VSSE VDDPE VDDCE
** icache_tag_storeMWL_ROW40LO: 246 flat devices **
XCC1 BL_1 BL__0 DIFF1_0 DIFF2_0 GDL_1 PG0_1 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC10 BL_10 BL__9 DIFF1_9 DIFF2_9 GDL_10 PG0_10 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC11 BL_11 BL__10 DIFF1_10 DIFF2_10 GDL_11 PG0_11 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC12 BL_12 BL__11 DIFF1_11 DIFF2_11 GDL_12 PG0_12 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC13 BL_13 BL__12 DIFF1_12 DIFF2_12 GDL_13 PG0_13 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC14 BL_14 BL__13 DIFF1_13 DIFF2_13 GDL_14 PG0_14 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC15 BL_15 BL__14 DIFF1_14 DIFF2_14 GDL_15 PG0_15 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC16 BL_16 BL__15 DIFF1_15 DIFF2_15 GDL_16 PG0_16 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC17 BL_17 BL__16 DIFF1_16 DIFF2_16 GDL_17 PG0_17 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC18 BL_18 BL__17 DIFF1_17 DIFF2_17 GDL_18 PG0_18 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC19 BL_19 BL__18 DIFF1_18 DIFF2_18 GDL_19 PG0_19 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC2 BL_2 BL__1 DIFF1_1 DIFF2_1 GDL_2 PG0_2 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC20 BL_20 BL__19 DIFF1_19 DIFF2_19 GDL_20 PG0_20 TL0_1 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeFLMW
XCC21 BL_21 BL__20 DIFF1_20 DIFF2_20 GDL_21 PG0_21 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC22 BL_22 BL__21 DIFF1_21 DIFF2_21 GDL_22 PG0_22 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC23 BL_23 BL__22 DIFF1_22 DIFF2_22 GDL_23 PG0_23 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC24 BL_24 BL__23 DIFF1_23 DIFF2_23 GDL_24 PG0_24 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC25 BL_25 BL__24 DIFF1_24 DIFF2_24 GDL_25 PG0_25 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC26 BL_26 BL__25 DIFF1_25 DIFF2_25 GDL_26 PG0_26 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC27 BL_27 BL__26 DIFF1_26 DIFF2_26 GDL_27 PG0_27 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC28 BL_28 BL__27 DIFF1_27 DIFF2_27 GDL_28 PG0_28 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC29 BL_29 BL__28 DIFF1_28 DIFF2_28 GDL_29 PG0_29 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC3 BL_3 BL__2 DIFF1_2 DIFF2_2 GDL_3 PG0_3 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC30 BL_30 BL__29 DIFF1_29 DIFF2_29 GDL_30 PG0_30 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC31 BL_31 BL__30 DIFF1_30 DIFF2_30 GDL_31 PG0_31 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC32 BL_32 BL__31 DIFF1_31 DIFF2_31 GDL_32 PG0_32 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC33 BL_33 BL__32 DIFF1_32 DIFF2_32 GDL_33 PG0_33 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC34 BL_34 BL__33 DIFF1_33 DIFF2_33 GDL_34 PG0_34 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC35 BL_35 BL__34 DIFF1_34 DIFF2_34 GDL_35 PG0_35 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC36 BL_36 BL__35 DIFF1_35 DIFF2_35 GDL_36 PG0_36 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC37 BL_37 BL__36 DIFF1_36 DIFF2_36 GDL_37 PG0_37 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC38 BL_38 BL__37 DIFF1_37 DIFF2_37 GDL_38 PG0_38 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC39 BL_39 BL__38 DIFF1_38 DIFF2_38 GDL_39 PG0_39 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC4 BL_4 BL__3 DIFF1_3 DIFF2_3 GDL_4 PG0_4 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC40 BL_40 BL__39 DIFF1_39 DIFF2_39 GDL_40 PG0_40 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC5 BL_5 BL__4 DIFF1_4 DIFF2_4 GDL_5 PG0_5 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC6 BL_6 BL__5 DIFF1_5 DIFF2_5 GDL_6 PG0_6 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC7 BL_7 BL__6 DIFF1_6 DIFF2_6 GDL_7 PG0_7 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC8 BL_8 BL__7 DIFF1_7 DIFF2_7 GDL_8 PG0_8 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC9 BL_9 BL__8 DIFF1_8 DIFF2_8 GDL_9 PG0_9 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeCCEDGE_CCMBL
.ENDS icache_tag_storeMWL_ROW40LO
****
.SUBCKT icache_tag_storeCCCAPBK BL BL_ DIFF1 GDL PG0 WL VSSE VDDPE VDDCE
** icache_tag_storeCCCAPBK: 6 flat devices **
M0 CORED CORED_ VDDCE VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M1 VDDCE CORED CORED_ VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M2 VSSE CORED_ CORED VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M3 CORED_ CORED VSSE VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M4 DIFF1 WL CORED VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N4/N00
M5 CORED_ WL BL_ VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS icache_tag_storeCCCAPBK
****
.SUBCKT icache_tag_storeCAPBK_ROW40LE BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 CCMBL DIFF DIFF1_0 DIFF1_1 DIFF1_2
+  DIFF1_3 DIFF1_4 DIFF1_5 DIFF1_6 DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11
+  DIFF1_12 DIFF1_13 DIFF1_14 DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19
+  DIFF1_20 DIFF1_21 DIFF1_22 DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27
+  DIFF1_28 DIFF1_29 DIFF1_30 DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35
+  DIFF1_36 DIFF1_37 DIFF1_38 DIFF1_39 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5
+  GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16
+  GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26
+  GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36
+  GDL_37 GDL_38 GDL_39 GDL_40 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL VSSE VDDPE VDDCE
** icache_tag_storeCAPBK_ROW40LE: 246 flat devices **
XCC1 BL_1 BL__0 DIFF1_0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC10 BL_10 BL__9 DIFF1_9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC11 BL_11 BL__10 DIFF1_10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC12 BL_12 BL__11 DIFF1_11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC13 BL_13 BL__12 DIFF1_12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC14 BL_14 BL__13 DIFF1_13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC15 BL_15 BL__14 DIFF1_14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC16 BL_16 BL__15 DIFF1_15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC17 BL_17 BL__16 DIFF1_16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC18 BL_18 BL__17 DIFF1_17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC19 BL_19 BL__18 DIFF1_18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC2 BL_2 BL__1 DIFF1_1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC20 BL_20 BL__19 DIFF1_19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC21 BL_21 BL__20 DIFF1_20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC22 BL_22 BL__21 DIFF1_21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC23 BL_23 BL__22 DIFF1_22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC24 BL_24 BL__23 DIFF1_23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC25 BL_25 BL__24 DIFF1_24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC26 BL_26 BL__25 DIFF1_25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC27 BL_27 BL__26 DIFF1_26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC28 BL_28 BL__27 DIFF1_27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC29 BL_29 BL__28 DIFF1_28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC3 BL_3 BL__2 DIFF1_2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC30 BL_30 BL__29 DIFF1_29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC31 BL_31 BL__30 DIFF1_30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC32 BL_32 BL__31 DIFF1_31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC33 BL_33 BL__32 DIFF1_32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC34 BL_34 BL__33 DIFF1_33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC35 BL_35 BL__34 DIFF1_34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC36 BL_36 BL__35 DIFF1_35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC37 BL_37 BL__36 DIFF1_36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC38 BL_38 BL__37 DIFF1_37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC39 BL_39 BL__38 DIFF1_38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC4 BL_4 BL__3 DIFF1_3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC40 BL_40 BL__39 DIFF1_39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC5 BL_5 BL__4 DIFF1_4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC6 BL_6 BL__5 DIFF1_5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC7 BL_7 BL__6 DIFF1_6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC8 BL_8 BL__7 DIFF1_7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC9 BL_9 BL__8 DIFF1_8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCEDGE_CCMBL
.ENDS icache_tag_storeCAPBK_ROW40LE
****
.SUBCKT icache_tag_storeCABL40X64TT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5
+  GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16
+  GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26
+  GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36
+  GDL_37 GDL_38 GDL_39 GDL_40 MBL PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6
+  PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17
+  PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27
+  PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37
+  PG0_38 PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WL_65 VSSE VDDPE
+  VDDCE
** icache_tag_storeCABL40X64TT: 16482 flat devices **
XCC_ROW0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_331 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_333 PDIFF_335 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_0 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_331 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_333 PDIFF_337 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_1 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW10 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_243 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_245 PDIFF_247 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_10 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW11 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_243 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_245 PDIFF_249 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_11 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW12 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_255 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_257 PDIFF_249 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_12 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW13 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_255 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_257 PDIFF_261 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_13 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_271 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_273 PDIFF_261 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_14 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_271 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_273 PDIFF_279 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_15 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW16 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_289 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_291 PDIFF_279 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_16 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW17 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_289 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_291 PDIFF_297 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_17 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW18 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_307 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_309 PDIFF_297 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_18 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW19 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_307 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_309 PDIFF_315 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_19 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW2 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_339 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_341 PDIFF_337 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_2 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW20 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF PDIFF_315 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_20 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW21 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8
+  PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 TL0_0 TL0_1 TL1 WL_21 VSSE VDDPE VDDCE icache_tag_storeCC_ROW40LO
XCC_ROW22 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_11 PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8
+  PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 TL0_0 TL0_1 TL1 WL_22 VSSE VDDPE VDDCE icache_tag_storeCC_ROW40LE
XCC_ROW23 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_11 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_23 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW24 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_27 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_29 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_24 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW25 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_27 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_29 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_25 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW26 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_45 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_47 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_26 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW27 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_45 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_47 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_27 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW28 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_59 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_61 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_28 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW29 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_59 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_61 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_29 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW3 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_339 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_341 PDIFF_343 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_3 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW30 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_251 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_253 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_30 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW31 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_251 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_253 PDIFF_259 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_31 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW32 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_263 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_265 PDIFF_259 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_32 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW33 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_263 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_265 PDIFF_275 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_33 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW34 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_281 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_283 PDIFF_275 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_34 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW35 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_281 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_283 PDIFF_293 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_35 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW36 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_299 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_301 PDIFF_293 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_36 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW37 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_299 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_301 PDIFF_311 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_37 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW38 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_317 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_319 PDIFF_311 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_38 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW39 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_317 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_319 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_39 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_345 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_347 PDIFF_343 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_4 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW40 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_5 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_40 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW41 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_5 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_41 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW42 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_17 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_19 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_42 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW43 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_17 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_19 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_43 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW44 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_37 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_39 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_44 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW45 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_37 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_39 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_45 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW46 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_55 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_57 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_46 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW47 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_55 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_57 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_47 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW48 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_67 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_69 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_48 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW49 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_67 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_69 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_49 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW5 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_345 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_347 PDIFF_349 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_5 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW50 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_267 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_269 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_50 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW51 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_267 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_269 PDIFF_277 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_51 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW52 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_285 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_287 PDIFF_277 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_52 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW53 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_285 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_287 PDIFF_295 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_53 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW54 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_303 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_305 PDIFF_295 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_54 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW55 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_303 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_305 PDIFF_313 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_55 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW56 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_321 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_323 PDIFF_313 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_56 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW57 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_321 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_323 PDIFF_325 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_57 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW58 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_327 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_329 PDIFF_325 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_58 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW59 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_327 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_329 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_59 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW6 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_351 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_353 PDIFF_349 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_6 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW60 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_21 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_23 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_60 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW61 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_21 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_23 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_61 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW62 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_41 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_43 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_62 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW63 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_41 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_43 PDIFF_51 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_63 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW7 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_351 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_353 PDIFF_355 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_7 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW8 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_357 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_359 PDIFF_355 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_8 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW9 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_357 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_359 PDIFF_247 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_9 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XI66 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13
+  BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25
+  BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37
+  BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 MBL
+  DIFF_239 DIFF1_0_237 DIFF1_1_235 DIFF1_2_233 DIFF1_3_231 DIFF1_4_229
+  DIFF1_5_227 DIFF1_6_225 DIFF1_7_223 DIFF1_8_221 DIFF1_9_219 DIFF1_10_217
+  DIFF1_11_215 DIFF1_12_213 DIFF1_13_211 DIFF1_14_209 DIFF1_15_207
+  DIFF1_16_205 DIFF1_17_203 DIFF1_18_201 DIFF1_19_199 DIFF1_20_197
+  DIFF1_21_195 DIFF1_22_193 DIFF1_23_191 DIFF1_24_189 DIFF1_25_187
+  DIFF1_26_185 DIFF1_27_183 DIFF1_28_181 DIFF1_29_179 DIFF1_30_177
+  DIFF1_31_175 DIFF1_32_173 DIFF1_33_171 DIFF1_34_169 DIFF1_35_167
+  DIFF1_36_165 DIFF1_37_163 DIFF1_38_161 DIFF1_39_159 GDL_0 GDL_1 GDL_2 GDL_3
+  GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24
+  GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34
+  GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 NDIFF_241 PDIFF_51 PG0_0 PG0_1
+  PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13
+  PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23
+  PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33
+  PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_64 VSSE
+  VDDPE VDDCE icache_tag_storeCAPBK_ROW40LE
XMWLROWBOT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_113 DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3 DIFF1_4 DIFF1_5 DIFF1_6
+  DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12 DIFF1_13 DIFF1_14
+  DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20 DIFF1_21 DIFF1_22
+  DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28 DIFF1_29 DIFF1_30
+  DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36 DIFF1_37 DIFF1_38
+  DIFF1_39 DIFF2_0 DIFF2_1 DIFF2_2 DIFF2_3 DIFF2_4 DIFF2_5 DIFF2_6 DIFF2_7
+  DIFF2_8 DIFF2_9 DIFF2_10 DIFF2_11 DIFF2_12 DIFF2_13 DIFF2_14 DIFF2_15
+  DIFF2_16 DIFF2_17 DIFF2_18 DIFF2_19 DIFF2_20 DIFF2_21 DIFF2_22 DIFF2_23
+  DIFF2_24 DIFF2_25 DIFF2_26 DIFF2_27 DIFF2_28 DIFF2_29 DIFF2_30 DIFF2_31
+  DIFF2_32 DIFF2_33 DIFF2_34 DIFF2_35 DIFF2_36 DIFF2_37 DIFF2_38 DIFF2_39
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 NDIFF_115
+  PDIFF_157 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9
+  PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 TL0_0 TL0_1 TL1 WL_65 VSSE VDDPE VDDCE icache_tag_storeMWL_ROW40LO
XMWLROWTOP BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_239 DIFF1_0_237 DIFF1_1_235 DIFF1_2_233 DIFF1_3_231
+  DIFF1_4_229 DIFF1_5_227 DIFF1_6_225 DIFF1_7_223 DIFF1_8_221 DIFF1_9_219
+  DIFF1_10_217 DIFF1_11_215 DIFF1_12_213 DIFF1_13_211 DIFF1_14_209
+  DIFF1_15_207 DIFF1_16_205 DIFF1_17_203 DIFF1_18_201 DIFF1_19_199
+  DIFF1_20_197 DIFF1_21_195 DIFF1_22_193 DIFF1_23_191 DIFF1_24_189
+  DIFF1_25_187 DIFF1_26_185 DIFF1_27_183 DIFF1_28_181 DIFF1_29_179
+  DIFF1_30_177 DIFF1_31_175 DIFF1_32_173 DIFF1_33_171 DIFF1_34_169
+  DIFF1_35_167 DIFF1_36_165 DIFF1_37_163 DIFF1_38_161 DIFF1_39_159 DIFF2_0
+  DIFF2_1 DIFF2_2 DIFF2_3 DIFF2_4 DIFF2_5 DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9
+  DIFF2_10 DIFF2_11 DIFF2_12 DIFF2_13 DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17
+  DIFF2_18 DIFF2_19 DIFF2_20 DIFF2_21 DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25
+  DIFF2_26 DIFF2_27 DIFF2_28 DIFF2_29 DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33
+  DIFF2_34 DIFF2_35 DIFF2_36 DIFF2_37 DIFF2_38 DIFF2_39 GDL_0 GDL_1 GDL_2
+  GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33
+  GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 NDIFF_241 PDIFF_157 PG0_0
+  PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12
+  PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22
+  PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32
+  PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 TL0_0 TL0_1 TL1
+  WL_65 VSSE VDDPE VDDCE icache_tag_storeMWL_ROW40LO
.ENDS icache_tag_storeCABL40X64TT
****
.SUBCKT icache_tag_storeWD4 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AX6N AY0TRACK AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTPIN0
+  G0 G0X G1 G1X GTP GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP
+  RRBTPB RRBTPT RREN RXP0B RXP0T RXP1B RXP1T RXP2B RXP2T RXP3B RXP3T WL0L
+  WL0R WL1L WL1R XP0 XP1 XP2 XP3 XP4 XP4_0 XP4_1 XP5 XP6 XP7 XP8 XP9 XP10
+  XP11 VSSE VDDPE VDDCE
** icache_tag_storeWD4: 70 flat devices **
M0 VDDCE WL1N WL1L VDDCE PCH W=2.88U L=0.06U M=1 $name=/P14/P00
M1 VDDCE WL0N WL0R VDDCE PCH W=2.88U L=0.06U M=1 $name=/P12/P00
M10 VDDCE WL1N WL1L VDDCE PCH W=2.88U L=0.06U M=1 $name=/P16/P00
M11 VDDCE WL1N WL1L VDDCE PCH W=2.88U L=0.06U M=1 $name=/P15/P00
M12 VDDCE WL0N WL0L VDDCE PCH W=2.88U L=0.06U M=1 $name=/P18/P00
M13 VDDCE WL0N WL0L VDDCE PCH W=2.88U L=0.06U M=1 $name=/P21/P00
M14 VDDCE WL0N WL0L VDDCE PCH W=2.88U L=0.06U M=1 $name=/P20/P00
M15 VDDCE WL0N WL0L VDDCE PCH W=2.88U L=0.06U M=1 $name=/P19/P00
M16 BTPIN0 WL0PD WL0I VDDCE PCH W=1.42U L=0.06U M=1 $name=/wl0ipgp/P00
M17 VDDPE XP4_0 WL0PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/tndp/P00
M18 VDDPE XP4_1 WL1PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/P4/P00
M19 VDDPE G0 WL1PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/P3/P00
M2 VDDCE WL0N WL0R VDDCE PCH W=2.88U L=0.06U M=1 $name=/P11/P00
M20 VDDPE G1 WL0PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/P2/P00
M21 BTPIN0 WL1PD WL1I VDDCE PCH W=1.42U L=0.06U M=1 $name=/P13/P00
M22 VDDPE G1 WL1PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/P1/P00
M23 VDDPE G0 WL0PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/P0/P00
M24 WL0I WL0PD VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/kprn/N00
M25 WL0I RET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N3/N00
M26 WL1I WL1PD VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/N20/N00
M27 WL1I RET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N2/N00
M28 VDDCE WL1I WL1N VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/P22/P00
M29 VDDCE WL1I WL1N VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/P23/P00
M3 VDDCE WL0N WL0R VDDCE PCH W=2.88U L=0.06U M=1 $name=/P10/P00
M30 VDDCE WL1I WL1N VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/P24/P00
M31 VDDCE WL0I WL0N VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/P25/P00
M32 VDDCE WL0I WL0N VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/P26/P00
M33 VDDCE WL0I WL0N VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/P27/P00
M34 VDDCE WL0I WL0N VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/wlndrp/P00
M35 VDDCE WL1I WL1N VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/N16/P00
M36 WL0N WL0I VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/N25/N00
M37 WL0N WL0I VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/N26/N00
M38 WL1N WL1I VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/N28/N00
M39 WL1N WL1I VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/N29/N00
M4 VDDCE WL0N WL0R VDDCE PCH W=2.88U L=0.06U M=1 $name=/P9/P00
M40 WL1N WL1I VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/N30/N00
M41 WL0N WL0I VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/N27/N00
M42 WL0R WL0N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N12/N00
M43 WL0R WL0N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N11/N00
M44 WL0R WL0N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N10/N00
M45 WL0L WL0N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N23/N00
M46 WL0L WL0N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N24/N00
M47 WL0R WL0N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N9/N00
M48 WL1R WL1N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N6/N00
M49 WL1R WL1N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N7/N00
M5 VDDCE WL1N WL1R VDDCE PCH W=2.88U L=0.06U M=1 $name=/P6/P00
M50 WL1R WL1N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N8/N00
M51 WL1R WL1N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N5/N00
M52 WL0L WL0N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N22/N00
M53 WL0L WL0N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N21/N00
M54 WL1L WL1N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N19/N00
M55 WL1L WL1N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N18/N00
M56 WL1L WL1N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N13/N00
M57 WL1L WL1N VSSE VSSE NCH W=0.81U L=0.06U M=1 $name=/N14/N00
M58 WL0N WL0I VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/wlndrn/N00
M59 WL0I WL0PDN BTPIN0 VSSE NCH W=0.8U L=0.06U M=1 $name=/wl0ipgn/N00
M6 VDDCE WL1N WL1R VDDCE PCH W=2.88U L=0.06U M=1 $name=/P7/P00
M60 NET55 G1 VSSE VSSE NCH W=0.93U L=0.06U M=1 $name=/tndn/N00
M61 WL1PD XP4_1 NET65 VSSE NCH W=0.93U L=0.06U M=1 $name=/N4/N00
M62 WL1I WL1PDN BTPIN0 VSSE NCH W=0.8U L=0.06U M=1 $name=/N17/N00
M63 WL1N WL1I VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/N15/N00
M64 NET65 G0 NET55 VSSE NCH W=0.93U L=0.06U M=1 $name=/N1/N00
M65 WL0PD XP4_0 NET65 VSSE NCH W=0.93U L=0.06U M=1 $name=/N0/N00
M66 WL0PDN WL0PD VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/gdrvb/N00
M67 VDDPE WL0PD WL0PDN VDDCE PCH W=0.28U L=0.06U M=1 $name=/gdrvb/P00
M68 WL1PDN WL1PD VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I15/N00
M69 VDDPE WL1PD WL1PDN VDDCE PCH W=0.28U L=0.06U M=1 $name=/I15/P00
M7 VDDCE WL1N WL1R VDDCE PCH W=2.88U L=0.06U M=1 $name=/P5/P00
M8 VDDCE WL1N WL1R VDDCE PCH W=2.88U L=0.06U M=1 $name=/P8/P00
M9 VDDCE WL1N WL1L VDDCE PCH W=2.88U L=0.06U M=1 $name=/P17/P00
.ENDS icache_tag_storeWD4
****
.SUBCKT icache_tag_storeMWD4 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AX6N AY0TRACK AY1TRACK AY2TRACK BS0N BS1N BTPTERM0 BTPTERM1
+  BTPTERM2 BTPTERM3 G0TERM G1TERM GTP GTPD GTPDE GTPIN IRET LGWEN MBL MGDLE
+  MGDLS MGTPE MGTPS MWL MWLLATE P1 P2 P3 P4 P5 P6 P7 P8 P9 P10 P11 P12 P13
+  PW1 PW2 PW3 RDTN RREN RXP0 RXP1 RXP2 RXP3 STUBMATCH0 STUBMATCH1 STUBMATCH2
+  STUBMATCH3 TIELOW WBT XP0TERM XP1TERM XP2TERM XP3TERM XP4TERM XP5TERM
+  XP6TERM XP7TERM XP8TERM XP9TERM XP10TERM XP11TERM VSSE VDDPE VDDCE
** icache_tag_storeMWD4: 60 flat devices **
M0 VDDCE WL1I NET409 VDDCE PCH_HVT W=2.88U L=0.06U M=1 $name=/mwlndrp/P00
M1 NET245 TIELOW VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/gdrvb/N00
M10 NET270 WBT VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N53/N00
M11 MBL MWLLATE NET270 VSSE NCH W=0.32U L=0.06U M=1 $name=/N54/N00
M12 MBL MWLLATE NET279 VSSE NCH W=0.32U L=0.06U M=1 $name=/N55/N00
M13 NET279 WBT VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N56/N00
M14 NET282 WBT VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N57/N00
M15 P12 MWLLATE NET282 VSSE NCH W=0.32U L=0.06U M=1 $name=/N58/N00
M16 P13 MWLLATE NET291 VSSE NCH W=0.32U L=0.06U M=1 $name=/N59/N00
M17 NET291 WBT VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N60/N00
M18 NET294 WBT VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N61/N00
M19 NET297 MWLLATE NET294 VSSE NCH W=0.32U L=0.06U M=1 $name=/N62/N00
M2 VDDPE TIELOW NET245 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/gdrvb/P00
M20 NET300 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N36/N00
M21 NET303 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N0/N00
M22 P1 MWLLATE NET330 VSSE NCH W=0.32U L=0.06U M=1 $name=/N46/N00
M23 P3 MWLLATE NET354 VSSE NCH W=0.32U L=0.06U M=1 $name=/N47/N00
M24 NET312 LGWEN VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N37/N00
M25 MBL MWLLATE MBL0 VSSE NCH W=0.32U L=0.06U M=1 $name=/N43/N00
M26 NET318 LGWEN VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N41/N00
M27 NET409 WL1I VSSE VSSE NCH W=4.2U L=0.06U M=1 $name=/mwlndrn/N00
M28 GTPIN NET245 WL1I VSSE NCH W=4.4U L=0.06U M=1 $name=/mwlipgn/N00
M29 P8 MWLLATE NET339 VSSE NCH W=0.32U L=0.06U M=1 $name=/N29/N00
M3 WL1I TIELOW GTPIN VDDCE PCH W=4.4U L=0.06U M=1 $name=/mwlipgp/P00
M30 NET330 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N45/N00
M31 P11 MWLLATE NET351 VSSE NCH W=0.32U L=0.06U M=1 $name=/N26/N00
M32 MBL0 LGWEN VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N44/N00
M33 NET339 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N31/N00
M34 PW1 MWLLATE NET318 VSSE NCH W=0.32U L=0.06U M=1 $name=/N42/N00
M35 P10 MWLLATE NET348 VSSE NCH W=0.32U L=0.06U M=1 $name=/N24/N00
M36 NET348 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N19/N00
M37 NET351 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N18/N00
M38 NET354 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N48/N00
M39 NET357 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N21/N00
M4 VDDPE TIEHI_INTERNAL TIEHI_INTERNAL VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M40 P4 MWLLATE NET366 VSSE NCH W=0.32U L=0.06U M=1 $name=/N34/N00
M41 NET363 MWLLATE NET303 VSSE NCH W=0.32U L=0.06U M=1 $name=/N27/N00
M42 NET366 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N33/N00
M43 P9 MWLLATE NET357 VSSE NCH W=0.32U L=0.06U M=1 $name=/N22/N00
M44 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N3/N00
M45 P6 MWLLATE NET381 VSSE NCH W=0.32U L=0.06U M=1 $name=/N30/N00
M46 TIELOW TIEHI_INTERNAL VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/N2/N00
M47 NET381 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N32/N00
M48 P2 MWLLATE NET300 VSSE NCH W=0.32U L=0.06U M=1 $name=/N35/N00
M49 NET387 LGWEN VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N40/N00
M5 VDDPE TIELOW TIEHI_INTERNAL VDDCE PCH W=0.3U L=0.06U M=1 $name=/P0/P00
M50 PW3 MWLLATE NET312 VSSE NCH W=0.32U L=0.06U M=1 $name=/N38/N00
M51 PW2 MWLLATE NET387 VSSE NCH W=0.32U L=0.06U M=1 $name=/N39/N00
M52 MWL IRET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N7/N00
M53 WL1I TIELOW VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/N20/N00
M54 VSSE IRET MWLL VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N17/N00
M55 WL1I IRET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N12/N00
M56 MWL NET409 VSSE VSSE NCH W=3.21U L=0.06U M=1 $name=/mwldrv/N00
M57 VDDCE NET409 MWL VDDCE PCH W=11.49U L=0.06U M=1 $name=/mwldrv/P00
M58 MWLL NET409 VSSE VSSE NCH W=6.21U L=0.06U M=1 $name=/I0/N00
M59 VDDCE NET409 MWLL VDDCE PCH W=8.49U L=0.06U M=1 $name=/I0/P00
M6 NET258 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N49/N00
M7 P5 MWLLATE NET258 VSSE NCH W=0.32U L=0.06U M=1 $name=/N50/N00
M8 P7 MWLLATE NET267 VSSE NCH W=0.32U L=0.06U M=1 $name=/N51/N00
M9 NET267 TIEHI_INTERNAL VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N52/N00
.ENDS icache_tag_storeMWD4
****
.SUBCKT icache_tag_storeWDTAP4 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AX6N AY0TRACK AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 G0TERM
+  G0_TIEHIGH G1TERM G1_TIEHIGH GTP GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS
+  RDTN RET RRBTP RREN RXP0 RXP1 RXP2 RXP3 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8
+  XP9 XP10 XP11 VSSE VDDPE VDDCE
** icache_tag_storeWDTAP4: 4 flat devices **
M0 NET139 NET139 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N3/N00
M1 NET139 G1_TIEHIGH VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/N2/N00
M2 VDDPE G1_TIEHIGH G1_TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M3 VDDPE NET139 G1_TIEHIGH VDDCE PCH W=5U L=0.06U M=1 $name=/P0/P00
.ENDS icache_tag_storeWDTAP4
****
.SUBCKT icache_tag_storeWDSEC0B64 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AX6N AY0TRACK AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 G0_TIEHIGH
+  G1_TIEHIGH GTP GTPD GTPDE IRET LGWEN MBL MGDLE MGDLS MGTPE MGTPS MWL
+  MWLLATE RDTN RREN RXP0_0 RXP0_1 RXP1_0 RXP1_1 RXP2_0 RXP2_1 RXP3_0 RXP3_1
+  TIELOW WBT WL0L_0 WL0L_1 WL0L_2 WL0L_3 WL0L_4 WL0L_5 WL0L_6 WL0L_7 WL0L_8
+  WL0L_9 WL0L_10 WL0L_11 WL0L_12 WL0L_13 WL0L_14 WL0L_15 WL0L_16 WL0L_17
+  WL0L_18 WL0L_19 WL0L_20 WL0L_21 WL0L_22 WL0L_23 WL0L_24 WL0L_25 WL0L_26
+  WL0L_27 WL0L_28 WL0L_29 WL0L_30 WL0L_31 WL0R_0 WL0R_1 WL0R_2 WL0R_3 WL0R_4
+  WL0R_5 WL0R_6 WL0R_7 WL0R_8 WL0R_9 WL0R_10 WL0R_11 WL0R_12 WL0R_13 WL0R_14
+  WL0R_15 WL0R_16 WL0R_17 WL0R_18 WL0R_19 WL0R_20 WL0R_21 WL0R_22 WL0R_23
+  WL0R_24 WL0R_25 WL0R_26 WL0R_27 WL0R_28 WL0R_29 WL0R_30 WL0R_31 WL1L_0
+  WL1L_1 WL1L_2 WL1L_3 WL1L_4 WL1L_5 WL1L_6 WL1L_7 WL1L_8 WL1L_9 WL1L_10
+  WL1L_11 WL1L_12 WL1L_13 WL1L_14 WL1L_15 WL1L_16 WL1L_17 WL1L_18 WL1L_19
+  WL1L_20 WL1L_21 WL1L_22 WL1L_23 WL1L_24 WL1L_25 WL1L_26 WL1L_27 WL1L_28
+  WL1L_29 WL1L_30 WL1L_31 WL1R_0 WL1R_1 WL1R_2 WL1R_3 WL1R_4 WL1R_5 WL1R_6
+  WL1R_7 WL1R_8 WL1R_9 WL1R_10 WL1R_11 WL1R_12 WL1R_13 WL1R_14 WL1R_15
+  WL1R_16 WL1R_17 WL1R_18 WL1R_19 WL1R_20 WL1R_21 WL1R_22 WL1R_23 WL1R_24
+  WL1R_25 WL1R_26 WL1R_27 WL1R_28 WL1R_29 WL1R_30 WL1R_31 XP0 XP1 XP2 XP3 XP4
+  XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
** icache_tag_storeWDSEC0B64: 2304 flat devices **
XBOTTAP AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE XP4 G0_TIEHIGH XP8
+  G1_TIEHIGH GTP GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE RREN
+  RXP0_1 RXP1_1 RXP2_1 RXP3_1 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10
+  XP11 VSSE VDDPE VDDCE icache_tag_storeWDTAP4
XMWD AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE XP7 XP9 GTP GTPD GTPDE
+  MGTPS IRET LGWEN MBL MGDLE MGDLS MGTPE MGTPS MWL MWLLATE MBL MBL MBL MBL
+  MBL P6 P7 P8 P9 P10 P11 P12 P13 MBL MBL MBL RDTN RREN RXP0_0 RXP1_0 RXP2_0
+  RXP3_0 TIELOW TIELOW TIELOW TIELOW TIELOW WBT XP0 XP1 XP2 XP3 XP4 XP5 XP6
+  XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE icache_tag_storeMWD4
XWD1 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP4 XP4 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_1 RXP0_0 RXP1_1 RXP1_0 RXP2_1 RXP2_0 RXP3_1 RXP3_0 WL0L_0 WL0R_0
+  WL1L_0 WL1R_0 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD10 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP4 XP5 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_9 WL0R_9
+  WL1L_9 WL1R_9 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD11 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP5 XP5 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_10 WL0R_10
+  WL1L_10 WL1R_10 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD12 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP5 XP6 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_11 WL0R_11
+  WL1L_11 WL1R_11 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD13 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP6 XP6 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_12 WL0R_12
+  WL1L_12 WL1R_12 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD14 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP6 XP7 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_13 WL0R_13
+  WL1L_13 WL1R_13 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD15 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP7 XP7 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_14 WL0R_14
+  WL1L_14 WL1R_14 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD16 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP7 XP4 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_15 WL0R_15
+  WL1L_15 WL1R_15 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD17 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP4 XP4 XP8 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_16 WL0R_16
+  WL1L_16 WL1R_16 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD18 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP4 XP5 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_17 WL0R_17
+  WL1L_17 WL1R_17 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD19 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP5 XP5 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_18 WL0R_18
+  WL1L_18 WL1R_18 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD2 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP4 XP5 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_1 WL0R_1
+  WL1L_1 WL1R_1 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD20 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP5 XP6 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_19 WL0R_19
+  WL1L_19 WL1R_19 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD21 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP6 XP6 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_20 WL0R_20
+  WL1L_20 WL1R_20 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD22 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP6 XP7 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_21 WL0R_21
+  WL1L_21 WL1R_21 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD23 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP7 XP7 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_22 WL0R_22
+  WL1L_22 WL1R_22 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD24 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP7 XP4 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_23 WL0R_23
+  WL1L_23 WL1R_23 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD25 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP4 XP4 XP9 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_24 WL0R_24
+  WL1L_24 WL1R_24 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD26 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP4 XP5 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_25 WL0R_25
+  WL1L_25 WL1R_25 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD27 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP5 XP5 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_26 WL0R_26
+  WL1L_26 WL1R_26 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD28 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP5 XP6 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_27 WL0R_27
+  WL1L_27 WL1R_27 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD29 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP6 XP6 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_28 WL0R_28
+  WL1L_28 WL1R_28 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD3 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP5 XP5 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_2 WL0R_2
+  WL1L_2 WL1R_2 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD30 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP6 XP7 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_29 WL0R_29
+  WL1L_29 WL1R_29 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD31 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP7 XP7 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_30 WL0R_30
+  WL1L_30 WL1R_30 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD32 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP1 XP7 XP7 XP9 XP9 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_31 WL0R_31
+  WL1L_31 WL1R_31 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD4 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP5 XP6 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_3 WL0R_3
+  WL1L_3 WL1R_3 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD5 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP6 XP6 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_4 WL0R_4
+  WL1L_4 WL1R_4 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD6 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP6 XP7 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_5 WL0R_5
+  WL1L_5 WL1R_5 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD7 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP7 XP7 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_6 WL0R_6
+  WL1L_6 WL1R_6 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD8 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP7 XP4 XP8 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_7 WL0R_7
+  WL1L_7 WL1R_7 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
XWD9 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 VSSE VSSE BTP0 XP4 XP4 XP9 XP8 GTP
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN IRET VSSE VSSE VSSE RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_8 WL0R_8
+  WL1L_8 WL1R_8 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWD4
.ENDS icache_tag_storeWDSEC0B64
****
.SUBCKT icache_tag_storeCC_ROW44RO BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31
+  BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41
+  BL__42 BL__43 CCMBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7
+  GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18
+  GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28
+  GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38
+  GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 NDIFF PDIFF PG0_0 PG0_1 PG0_2
+  PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13
+  PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23
+  PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33
+  PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43
+  PG0_44 TL0_0 TL0_1 TL1 WL VSSE VDDPE VDDCE
** icache_tag_storeCC_ROW44RO: 270 flat devices **
XCC1 BL_1 BL__0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC10 BL_10 BL__9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC11 BL_11 BL__10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC12 BL_12 BL__11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC13 BL_13 BL__12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC14 BL_14 BL__13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC15 BL_15 BL__14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC16 BL_16 BL__15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC17 BL_17 BL__16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC18 BL_18 BL__17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC19 BL_19 BL__18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC2 BL_2 BL__1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC20 BL_20 BL__19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC21 BL_21 BL__20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC22 BL_22 BL__21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC23 BL_23 BL__22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC24 BL_24 BL__23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC25 BL_25 BL__24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC26 BL_26 BL__25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC27 BL_27 BL__26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC28 BL_28 BL__27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC29 BL_29 BL__28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC3 BL_3 BL__2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC30 BL_30 BL__29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC31 BL_31 BL__30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC32 BL_32 BL__31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC33 BL_33 BL__32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC34 BL_34 BL__33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC35 BL_35 BL__34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC36 BL_36 BL__35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC37 BL_37 BL__36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC38 BL_38 BL__37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC39 BL_39 BL__38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC4 BL_4 BL__3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC40 BL_40 BL__39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC41 BL_41 BL__40 GDL_41 PG0_41 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC42 BL_42 BL__41 GDL_42 PG0_42 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC43 BL_43 BL__42 GDL_43 PG0_43 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC44 BL_44 BL__43 GDL_44 PG0_44 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC5 BL_5 BL__4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC6 BL_6 BL__5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC7 BL_7 BL__6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC8 BL_8 BL__7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC9 BL_9 BL__8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCEDGE_CCMBL
.ENDS icache_tag_storeCC_ROW44RO
****
.SUBCKT icache_tag_storeCC_ROW44RE BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31
+  BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41
+  BL__42 BL__43 CCMBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7
+  GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18
+  GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28
+  GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38
+  GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 NDIFF PDIFF PG0_0 PG0_1 PG0_2
+  PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13
+  PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23
+  PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33
+  PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43
+  PG0_44 TL0_0 TL0_1 TL1 WL VSSE VDDPE VDDCE
** icache_tag_storeCC_ROW44RE: 270 flat devices **
XCC1 BL_1 BL__0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC10 BL_10 BL__9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC11 BL_11 BL__10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC12 BL_12 BL__11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC13 BL_13 BL__12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC14 BL_14 BL__13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC15 BL_15 BL__14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC16 BL_16 BL__15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC17 BL_17 BL__16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC18 BL_18 BL__17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC19 BL_19 BL__18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC2 BL_2 BL__1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC20 BL_20 BL__19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC21 BL_21 BL__20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC22 BL_22 BL__21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC23 BL_23 BL__22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC24 BL_24 BL__23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC25 BL_25 BL__24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC26 BL_26 BL__25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC27 BL_27 BL__26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC28 BL_28 BL__27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC29 BL_29 BL__28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC3 BL_3 BL__2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC30 BL_30 BL__29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC31 BL_31 BL__30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC32 BL_32 BL__31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC33 BL_33 BL__32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC34 BL_34 BL__33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC35 BL_35 BL__34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC36 BL_36 BL__35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC37 BL_37 BL__36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC38 BL_38 BL__37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC39 BL_39 BL__38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC4 BL_4 BL__3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC40 BL_40 BL__39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC41 BL_41 BL__40 GDL_41 PG0_41 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC42 BL_42 BL__41 GDL_42 PG0_42 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC43 BL_43 BL__42 GDL_43 PG0_43 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC44 BL_44 BL__43 GDL_44 PG0_44 WL VSSE VDDPE VDDCE
+  icache_tag_storeWRAPPED_CC
XCC5 BL_5 BL__4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC6 BL_6 BL__5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC7 BL_7 BL__6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC8 BL_8 BL__7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XCC9 BL_9 BL__8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE icache_tag_storeWRAPPED_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCEDGE_CCMBL
.ENDS icache_tag_storeCC_ROW44RE
****
.SUBCKT icache_tag_storeMWL_ROW44RO BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31
+  BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41
+  BL__42 BL__43 CCMBL DIFF DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3 DIFF1_4 DIFF1_5
+  DIFF1_6 DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12 DIFF1_13
+  DIFF1_14 DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20 DIFF1_21
+  DIFF1_22 DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28 DIFF1_29
+  DIFF1_30 DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36 DIFF1_37
+  DIFF1_38 DIFF1_39 DIFF1_40 DIFF1_41 DIFF1_42 DIFF1_43 DIFF2_0 DIFF2_1
+  DIFF2_2 DIFF2_3 DIFF2_4 DIFF2_5 DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10
+  DIFF2_11 DIFF2_12 DIFF2_13 DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18
+  DIFF2_19 DIFF2_20 DIFF2_21 DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26
+  DIFF2_27 DIFF2_28 DIFF2_29 DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34
+  DIFF2_35 DIFF2_36 DIFF2_37 DIFF2_38 DIFF2_39 DIFF2_40 DIFF2_41 DIFF2_42
+  DIFF2_43 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1 WL1
+  VSSE VDDPE VDDCE
** icache_tag_storeMWL_ROW44RO: 270 flat devices **
XCC1 BL_1 BL__0 DIFF1_0 DIFF2_0 GDL_1 PG0_1 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC10 BL_10 BL__9 DIFF1_9 DIFF2_9 GDL_10 PG0_10 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC11 BL_11 BL__10 DIFF1_10 DIFF2_10 GDL_11 PG0_11 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC12 BL_12 BL__11 DIFF1_11 DIFF2_11 GDL_12 PG0_12 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC13 BL_13 BL__12 DIFF1_12 DIFF2_12 GDL_13 PG0_13 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC14 BL_14 BL__13 DIFF1_13 DIFF2_13 GDL_14 PG0_14 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC15 BL_15 BL__14 DIFF1_14 DIFF2_14 GDL_15 PG0_15 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC16 BL_16 BL__15 DIFF1_15 DIFF2_15 GDL_16 PG0_16 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC17 BL_17 BL__16 DIFF1_16 DIFF2_16 GDL_17 PG0_17 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC18 BL_18 BL__17 DIFF1_17 DIFF2_17 GDL_18 PG0_18 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC19 BL_19 BL__18 DIFF1_18 DIFF2_18 GDL_19 PG0_19 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC2 BL_2 BL__1 DIFF1_1 DIFF2_1 GDL_2 PG0_2 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC20 BL_20 BL__19 DIFF1_19 DIFF2_19 GDL_20 PG0_20 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC21 BL_21 BL__20 DIFF1_20 DIFF2_20 GDL_21 PG0_21 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC22 BL_22 BL__21 DIFF1_21 DIFF2_21 GDL_22 PG0_22 TL0_1 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeFLMW
XCC23 BL_23 BL__22 DIFF1_22 DIFF2_22 GDL_23 PG0_23 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC24 BL_24 BL__23 DIFF1_23 DIFF2_23 GDL_24 PG0_24 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC25 BL_25 BL__24 DIFF1_24 DIFF2_24 GDL_25 PG0_25 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC26 BL_26 BL__25 DIFF1_25 DIFF2_25 GDL_26 PG0_26 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC27 BL_27 BL__26 DIFF1_26 DIFF2_26 GDL_27 PG0_27 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC28 BL_28 BL__27 DIFF1_27 DIFF2_27 GDL_28 PG0_28 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC29 BL_29 BL__28 DIFF1_28 DIFF2_28 GDL_29 PG0_29 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC3 BL_3 BL__2 DIFF1_2 DIFF2_2 GDL_3 PG0_3 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC30 BL_30 BL__29 DIFF1_29 DIFF2_29 GDL_30 PG0_30 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC31 BL_31 BL__30 DIFF1_30 DIFF2_30 GDL_31 PG0_31 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC32 BL_32 BL__31 DIFF1_31 DIFF2_31 GDL_32 PG0_32 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC33 BL_33 BL__32 DIFF1_32 DIFF2_32 GDL_33 PG0_33 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC34 BL_34 BL__33 DIFF1_33 DIFF2_33 GDL_34 PG0_34 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC35 BL_35 BL__34 DIFF1_34 DIFF2_34 GDL_35 PG0_35 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC36 BL_36 BL__35 DIFF1_35 DIFF2_35 GDL_36 PG0_36 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC37 BL_37 BL__36 DIFF1_36 DIFF2_36 GDL_37 PG0_37 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC38 BL_38 BL__37 DIFF1_37 DIFF2_37 GDL_38 PG0_38 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC39 BL_39 BL__38 DIFF1_38 DIFF2_38 GDL_39 PG0_39 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC4 BL_4 BL__3 DIFF1_3 DIFF2_3 GDL_4 PG0_4 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC40 BL_40 BL__39 DIFF1_39 DIFF2_39 GDL_40 PG0_40 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC41 BL_41 BL__40 DIFF1_40 DIFF2_40 GDL_41 PG0_41 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC42 BL_42 BL__41 DIFF1_41 DIFF2_41 GDL_42 PG0_42 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC43 BL_43 BL__42 DIFF1_42 DIFF2_42 GDL_43 PG0_43 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC44 BL_44 BL__43 DIFF1_43 DIFF2_43 GDL_44 PG0_44 TL0_1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC5 BL_5 BL__4 DIFF1_4 DIFF2_4 GDL_5 PG0_5 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC6 BL_6 BL__5 DIFF1_5 DIFF2_5 GDL_6 PG0_6 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC7 BL_7 BL__6 DIFF1_6 DIFF2_6 GDL_7 PG0_7 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC8 BL_8 BL__7 DIFF1_7 DIFF2_7 GDL_8 PG0_8 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XCC9 BL_9 BL__8 DIFF1_8 DIFF2_8 GDL_9 PG0_9 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeMWL_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL1 VSSE VDDPE VDDCE
+  icache_tag_storeCCEDGE_CCMBL
.ENDS icache_tag_storeMWL_ROW44RO
****
.SUBCKT icache_tag_storeCAPBK_ROW44RE BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31
+  BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41
+  BL__42 BL__43 CCMBL DIFF DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3 DIFF1_4 DIFF1_5
+  DIFF1_6 DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12 DIFF1_13
+  DIFF1_14 DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20 DIFF1_21
+  DIFF1_22 DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28 DIFF1_29
+  DIFF1_30 DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36 DIFF1_37
+  DIFF1_38 DIFF1_39 DIFF1_40 DIFF1_41 DIFF1_42 DIFF1_43 GDL_0 GDL_1 GDL_2
+  GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33
+  GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43
+  GDL_44 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8
+  PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1 WL VSSE VDDPE VDDCE
** icache_tag_storeCAPBK_ROW44RE: 270 flat devices **
XCC1 BL_1 BL__0 DIFF1_0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC10 BL_10 BL__9 DIFF1_9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC11 BL_11 BL__10 DIFF1_10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC12 BL_12 BL__11 DIFF1_11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC13 BL_13 BL__12 DIFF1_12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC14 BL_14 BL__13 DIFF1_13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC15 BL_15 BL__14 DIFF1_14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC16 BL_16 BL__15 DIFF1_15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC17 BL_17 BL__16 DIFF1_16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC18 BL_18 BL__17 DIFF1_17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC19 BL_19 BL__18 DIFF1_18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC2 BL_2 BL__1 DIFF1_1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC20 BL_20 BL__19 DIFF1_19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC21 BL_21 BL__20 DIFF1_20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC22 BL_22 BL__21 DIFF1_21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC23 BL_23 BL__22 DIFF1_22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC24 BL_24 BL__23 DIFF1_23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC25 BL_25 BL__24 DIFF1_24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC26 BL_26 BL__25 DIFF1_25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC27 BL_27 BL__26 DIFF1_26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC28 BL_28 BL__27 DIFF1_27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC29 BL_29 BL__28 DIFF1_28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC3 BL_3 BL__2 DIFF1_2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC30 BL_30 BL__29 DIFF1_29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC31 BL_31 BL__30 DIFF1_30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC32 BL_32 BL__31 DIFF1_31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC33 BL_33 BL__32 DIFF1_32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC34 BL_34 BL__33 DIFF1_33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC35 BL_35 BL__34 DIFF1_34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC36 BL_36 BL__35 DIFF1_35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC37 BL_37 BL__36 DIFF1_36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC38 BL_38 BL__37 DIFF1_37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC39 BL_39 BL__38 DIFF1_38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC4 BL_4 BL__3 DIFF1_3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC40 BL_40 BL__39 DIFF1_39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC41 BL_41 BL__40 DIFF1_40 GDL_41 PG0_41 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC42 BL_42 BL__41 DIFF1_41 GDL_42 PG0_42 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC43 BL_43 BL__42 DIFF1_42 GDL_43 PG0_43 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC44 BL_44 BL__43 DIFF1_43 GDL_44 PG0_44 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC5 BL_5 BL__4 DIFF1_4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC6 BL_6 BL__5 DIFF1_5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC7 BL_7 BL__6 DIFF1_6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC8 BL_8 BL__7 DIFF1_7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XCC9 BL_9 BL__8 DIFF1_8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCCAPBK
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  icache_tag_storeCCEDGE_CCMBL
.ENDS icache_tag_storeCAPBK_ROW44RE
****
.SUBCKT icache_tag_storeCABR44X64TT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31
+  BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41
+  BL__42 BL__43 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 MBL PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 WL_64 WL_65 VSSE VDDPE VDDCE
** icache_tag_storeCABR44X64TT: 18090 flat devices **
XCC_ROW0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_347
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_349 PDIFF_351 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_0 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_347
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_349 PDIFF_353 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_1 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW10 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_259
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_261 PDIFF_263 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_10 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW11 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_259
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_261 PDIFF_265 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_11 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW12 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_271
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_273 PDIFF_265 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_12 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW13 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_271
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_273 PDIFF_277 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_13 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_287
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_289 PDIFF_277 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_14 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_287
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_289 PDIFF_295 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_15 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW16 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_305
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_307 PDIFF_295 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_16 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW17 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_305
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_307 PDIFF_313 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_17 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW18 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_323
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_325 PDIFF_313 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_18 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW19 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_323
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_325 PDIFF_331 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_19 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW2 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_355
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_357 PDIFF_353 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_2 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW20 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF PDIFF_331 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_20 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW21 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6
+  PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17
+  PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27
+  PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37
+  PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1 WL_21 VSSE
+  VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW22 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_9
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_11 PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_22 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW23 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_9
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_11 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_23 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW24 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_27
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_29 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_24 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW25 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_27
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_29 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_25 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW26 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_45
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_47 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_26 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW27 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_45
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_47 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_27 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW28 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_59
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_61 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_28 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW29 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_59
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_61 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_29 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW3 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_355
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_357 PDIFF_359 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_3 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW30 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_267
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_269 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_30 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW31 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_267
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_269 PDIFF_275 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_31 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW32 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_279
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_281 PDIFF_275 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_32 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW33 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_279
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_281 PDIFF_291 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_33 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW34 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_297
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_299 PDIFF_291 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_34 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW35 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_297
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_299 PDIFF_309 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_35 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW36 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_315
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_317 PDIFF_309 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_36 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW37 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_315
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_317 PDIFF_327 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_37 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW38 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_333
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_335 PDIFF_327 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_38 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW39 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_333
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_335 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_39 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_361
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_363 PDIFF_359 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_4 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW40 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_3
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_5 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_40 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW41 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_3
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_5 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_41 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW42 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_17
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_19 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_42 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW43 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_17
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_19 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_43 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW44 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_37
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_39 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_44 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW45 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_37
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_39 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_45 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW46 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_55
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_57 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_46 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW47 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_55
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_57 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_47 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW48 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_67
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_69 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_48 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW49 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_67
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_69 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_49 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW5 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_361
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_363 PDIFF_365 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_5 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW50 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_283
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_285 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_50 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW51 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_283
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_285 PDIFF_293 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_51 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW52 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_301
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_303 PDIFF_293 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_52 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW53 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_301
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_303 PDIFF_311 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_53 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW54 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_319
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_321 PDIFF_311 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_54 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW55 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_319
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_321 PDIFF_329 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_55 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW56 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_337
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_339 PDIFF_329 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_56 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW57 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_337
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_339 PDIFF_341 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_57 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW58 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_343
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_345 PDIFF_341 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_58 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW59 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_343
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_345 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_59 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW6 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_367
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_369 PDIFF_365 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_6 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW60 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_21
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_23 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_60 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW61 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_21
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_23 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_61 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW62 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_41
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_43 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_62 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW63 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_41
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_43 PDIFF_51 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_63 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW7 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_367
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_369 PDIFF_371 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_7 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW8 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_373
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_375 PDIFF_371 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_8 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW9 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_373
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_375 PDIFF_263 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_9 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XI66 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13
+  BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25
+  BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37
+  BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15
+  BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25
+  BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35
+  BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_255
+  DIFF1_0_253 DIFF1_1_251 DIFF1_2_249 DIFF1_3_247 DIFF1_4_245 DIFF1_5_243
+  DIFF1_6_241 DIFF1_7_239 DIFF1_8_237 DIFF1_9_235 DIFF1_10_233 DIFF1_11_231
+  DIFF1_12_229 DIFF1_13_227 DIFF1_14_225 DIFF1_15_223 DIFF1_16_221
+  DIFF1_17_219 DIFF1_18_217 DIFF1_19_215 DIFF1_20_213 DIFF1_21_211
+  DIFF1_22_209 DIFF1_23_207 DIFF1_24_205 DIFF1_25_203 DIFF1_26_201
+  DIFF1_27_199 DIFF1_28_197 DIFF1_29_195 DIFF1_30_193 DIFF1_31_191
+  DIFF1_32_189 DIFF1_33_187 DIFF1_34_185 DIFF1_35_183 DIFF1_36_181
+  DIFF1_37_179 DIFF1_38_177 DIFF1_39_175 DIFF1_40_173 DIFF1_41_171
+  DIFF1_42_169 DIFF1_43_167 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7
+  GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18
+  GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28
+  GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38
+  GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 NDIFF_257 PDIFF_51 PG0_0 PG0_1
+  PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13
+  PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23
+  PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33
+  PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43
+  PG0_44 TL0_0 TL0_1 TL1 WL_64 VSSE VDDPE VDDCE icache_tag_storeCAPBK_ROW44RE
XMWLROWBOT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_117
+  DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3 DIFF1_4 DIFF1_5 DIFF1_6 DIFF1_7 DIFF1_8
+  DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12 DIFF1_13 DIFF1_14 DIFF1_15 DIFF1_16
+  DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20 DIFF1_21 DIFF1_22 DIFF1_23 DIFF1_24
+  DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28 DIFF1_29 DIFF1_30 DIFF1_31 DIFF1_32
+  DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36 DIFF1_37 DIFF1_38 DIFF1_39 DIFF1_40
+  DIFF1_41 DIFF1_42 DIFF1_43 DIFF2_0 DIFF2_1 DIFF2_2 DIFF2_3 DIFF2_4 DIFF2_5
+  DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10 DIFF2_11 DIFF2_12 DIFF2_13
+  DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18 DIFF2_19 DIFF2_20 DIFF2_21
+  DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26 DIFF2_27 DIFF2_28 DIFF2_29
+  DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34 DIFF2_35 DIFF2_36 DIFF2_37
+  DIFF2_38 DIFF2_39 DIFF2_40 DIFF2_41 DIFF2_42 DIFF2_43 GDL_0 GDL_1 GDL_2
+  GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33
+  GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43
+  GDL_44 NDIFF_119 PDIFF_165 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1 WL_65 VSSE VDDPE
+  VDDCE icache_tag_storeMWL_ROW44RO
XMWLROWTOP BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_255
+  DIFF1_0_253 DIFF1_1_251 DIFF1_2_249 DIFF1_3_247 DIFF1_4_245 DIFF1_5_243
+  DIFF1_6_241 DIFF1_7_239 DIFF1_8_237 DIFF1_9_235 DIFF1_10_233 DIFF1_11_231
+  DIFF1_12_229 DIFF1_13_227 DIFF1_14_225 DIFF1_15_223 DIFF1_16_221
+  DIFF1_17_219 DIFF1_18_217 DIFF1_19_215 DIFF1_20_213 DIFF1_21_211
+  DIFF1_22_209 DIFF1_23_207 DIFF1_24_205 DIFF1_25_203 DIFF1_26_201
+  DIFF1_27_199 DIFF1_28_197 DIFF1_29_195 DIFF1_30_193 DIFF1_31_191
+  DIFF1_32_189 DIFF1_33_187 DIFF1_34_185 DIFF1_35_183 DIFF1_36_181
+  DIFF1_37_179 DIFF1_38_177 DIFF1_39_175 DIFF1_40_173 DIFF1_41_171
+  DIFF1_42_169 DIFF1_43_167 DIFF2_0 DIFF2_1 DIFF2_2 DIFF2_3 DIFF2_4 DIFF2_5
+  DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10 DIFF2_11 DIFF2_12 DIFF2_13
+  DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18 DIFF2_19 DIFF2_20 DIFF2_21
+  DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26 DIFF2_27 DIFF2_28 DIFF2_29
+  DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34 DIFF2_35 DIFF2_36 DIFF2_37
+  DIFF2_38 DIFF2_39 DIFF2_40 DIFF2_41 DIFF2_42 DIFF2_43 GDL_0 GDL_1 GDL_2
+  GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33
+  GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43
+  GDL_44 NDIFF_257 PDIFF_165 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1 WL_65 VSSE VDDPE
+  VDDCE icache_tag_storeMWL_ROW44RO
.ENDS icache_tag_storeCABR44X64TT
****
.SUBCKT icache_tag_storeBK0B21X64 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AX6N AY0TRACK AY1TRACK AY2TRACK BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19
+  BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31
+  BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43
+  BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55
+  BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67
+  BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79
+  BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BS0N BS1N BTP0 BTP1
+  G0_TIEHIGH G1_TIEHIGH GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49
+  GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59
+  GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69
+  GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79
+  GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GTP GTPD GTPDE IRET LGWEN MBL
+  MGDLE MGDLS MGTPE MGTPS MWLLATE PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6
+  PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17
+  PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27
+  PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37
+  PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47
+  PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57
+  PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67
+  PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77
+  PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 RDTN RREN RXP0_0
+  RXP0_1 RXP1_0 RXP1_1 RXP2_0 RXP2_1 RXP3_0 RXP3_1 STUBMATCH0 TL0_0 TL0_1
+  TL0_2 TL0_3 TL1_0 TL1_1 WBT XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10
+  XP11 VSSE VDDPE VDDCE
** icache_tag_storeBK0B21X64: 36876 flat devices **
XLEFTCOREBANK0 BL_40 BL_39 BL_38 BL_37 BL_36 BL_35 BL_34 BL_33 BL_32 BL_31
+  BL_30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL_22 BL_21 BL_20 BL_19
+  BL_18 BL_17 BL_16 BL_15 BL_14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL_6
+  BL_5 BL_4 BL_3 BL_2 BL_1 BL_0 BL__39 BL__38 BL__37 BL__36 BL__35 BL__34
+  BL__33 BL__32 BL__31 BL__30 BL__29 BL__28 BL__27 BL__26 BL__25 BL__24
+  BL__23 BL__22 BL__21 BL__20 BL__19 BL__18 BL__17 BL__16 BL__15 BL__14
+  BL__13 BL__12 BL__11 BL__10 BL__9 BL__8 BL__7 BL__6 BL__5 BL__4 BL__3 BL__2
+  BL__1 BL__0 GDL_40 GDL_39 GDL_38 GDL_37 GDL_36 GDL_35 GDL_34 GDL_33 GDL_32
+  GDL_31 GDL_30 GDL_29 GDL_28 GDL_27 GDL_26 GDL_25 GDL_24 GDL_23 GDL_22
+  GDL_21 GDL_20 GDL_19 GDL_18 GDL_17 GDL_16 GDL_15 GDL_14 GDL_13 GDL_12
+  GDL_11 GDL_10 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5 GDL_4 GDL_3 GDL_2 GDL_1 GDL_0
+  STUBMATCH0 PG0_40 PG0_39 PG0_38 PG0_37 PG0_36 PG0_35 PG0_34 PG0_33 PG0_32
+  PG0_31 PG0_30 PG0_29 PG0_28 PG0_27 PG0_26 PG0_25 PG0_24 PG0_23 PG0_22
+  PG0_21 PG0_20 PG0_19 PG0_18 PG0_17 PG0_16 PG0_15 PG0_14 PG0_13 PG0_12
+  PG0_11 PG0_10 PG0_9 PG0_8 PG0_7 PG0_6 PG0_5 PG0_4 PG0_3 PG0_2 PG0_1 PG0_0
+  TL0_1 TL0_0 TL1_0 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL_63 STUBMATCH0 STUBMATCH0 VSSE VDDPE VDDCE
+  icache_tag_storeCABL40X64TT
XRIGHTCOREBANK0 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50
+  BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62
+  BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74
+  BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47
+  GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57
+  GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67
+  GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77
+  GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 MBL PG0_41 PG0_42
+  PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52
+  PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62
+  PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72
+  PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82
+  PG0_83 PG0_84 PG0_85 TL0_2 TL0_3 TL1_1 WL0R_0 WL1R_0 WL1R_1 WL0R_1 WL0R_2
+  WL1R_2 WL1R_3 WL0R_3 WL0R_4 WL1R_4 WL1R_5 WL0R_5 WL0R_6 WL1R_6 WL1R_7
+  WL0R_7 WL0R_8 WL1R_8 WL1R_9 WL0R_9 WL0R_10 WL1R_10 WL1R_11 WL0R_11 WL0R_12
+  WL1R_12 WL1R_13 WL0R_13 WL0R_14 WL1R_14 WL1R_15 WL0R_15 WL0R_16 WL1R_16
+  WL1R_17 WL0R_17 WL0R_18 WL1R_18 WL1R_19 WL0R_19 WL0R_20 WL1R_20 WL1R_21
+  WL0R_21 WL0R_22 WL1R_22 WL1R_23 WL0R_23 WL0R_24 WL1R_24 WL1R_25 WL0R_25
+  WL0R_26 WL1R_26 WL1R_27 WL0R_27 WL0R_28 WL1R_28 WL1R_29 WL0R_29 WL0R_30
+  WL1R_30 WL1R_31 WL0R_31 STUBMATCH0 MWLLATE VSSE VDDPE VDDCE
+  icache_tag_storeCABR44X64TT
XWDBANK0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 G0_TIEHIGH G1_TIEHIGH GTP GTPD GTPDE
+  IRET LGWEN MBL MGDLE MGDLS MGTPE MGTPS MWLLATE MWLLATE RDTN RREN RXP0_0
+  RXP0_1 RXP1_0 RXP1_1 RXP2_0 RXP2_1 RXP3_0 RXP3_1 STUBMATCH0 WBT WL_0 WL_3
+  WL_4 WL_7 WL_8 WL_11 WL_12 WL_15 WL_16 WL_19 WL_20 WL_23 WL_24 WL_27 WL_28
+  WL_31 WL_32 WL_35 WL_36 WL_39 WL_40 WL_43 WL_44 WL_47 WL_48 WL_51 WL_52
+  WL_55 WL_56 WL_59 WL_60 WL_63 WL0R_0 WL0R_1 WL0R_2 WL0R_3 WL0R_4 WL0R_5
+  WL0R_6 WL0R_7 WL0R_8 WL0R_9 WL0R_10 WL0R_11 WL0R_12 WL0R_13 WL0R_14 WL0R_15
+  WL0R_16 WL0R_17 WL0R_18 WL0R_19 WL0R_20 WL0R_21 WL0R_22 WL0R_23 WL0R_24
+  WL0R_25 WL0R_26 WL0R_27 WL0R_28 WL0R_29 WL0R_30 WL0R_31 WL_1 WL_2 WL_5 WL_6
+  WL_9 WL_10 WL_13 WL_14 WL_17 WL_18 WL_21 WL_22 WL_25 WL_26 WL_29 WL_30
+  WL_33 WL_34 WL_37 WL_38 WL_41 WL_42 WL_45 WL_46 WL_49 WL_50 WL_53 WL_54
+  WL_57 WL_58 WL_61 WL_62 WL1R_0 WL1R_1 WL1R_2 WL1R_3 WL1R_4 WL1R_5 WL1R_6
+  WL1R_7 WL1R_8 WL1R_9 WL1R_10 WL1R_11 WL1R_12 WL1R_13 WL1R_14 WL1R_15
+  WL1R_16 WL1R_17 WL1R_18 WL1R_19 WL1R_20 WL1R_21 WL1R_22 WL1R_23 WL1R_24
+  WL1R_25 WL1R_26 WL1R_27 WL1R_28 WL1R_29 WL1R_30 WL1R_31 XP0 XP1 XP2 XP3 XP4
+  XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE icache_tag_storeWDSEC0B64
.ENDS icache_tag_storeBK0B21X64
****
.SUBCKT icache_tag_storeCATL40X64TT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5
+  GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16
+  GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26
+  GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36
+  GDL_37 GDL_38 GDL_39 GDL_40 MBL PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6
+  PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17
+  PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27
+  PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37
+  PG0_38 PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 VSSE VDDPE VDDCE
** icache_tag_storeCATL40X64TT: 15744 flat devices **
XCC_ROW0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_161 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_163 PDIFF_165 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_0 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_161 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_163 PDIFF_167 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_1 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW10 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_73 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_75 PDIFF_77 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_10 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW11 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_73 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_75 PDIFF_79 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_11 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW12 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_85 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_87 PDIFF_79 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_12 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW13 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_85 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_87 PDIFF_91 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_13 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_101 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_103 PDIFF_91 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_14 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_101 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_103 PDIFF_109 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_15 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW16 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_119 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_121 PDIFF_109 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_16 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW17 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_119 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_121 PDIFF_127 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_17 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW18 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_137 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_139 PDIFF_127 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_18 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW19 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_137 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_139 PDIFF_145 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_19 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW2 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_169 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_171 PDIFF_167 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_2 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW20 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF PDIFF_145 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_20 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW21 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8
+  PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 TL0_0 TL0_1 TL1 WL_21 VSSE VDDPE VDDCE icache_tag_storeCC_ROW40LO
XCC_ROW22 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_11 PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8
+  PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 TL0_0 TL0_1 TL1 WL_22 VSSE VDDPE VDDCE icache_tag_storeCC_ROW40LE
XCC_ROW23 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_11 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_23 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW24 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_27 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_29 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_24 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW25 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_27 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_29 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_25 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW26 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_45 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_47 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_26 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW27 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_45 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_47 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_27 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW28 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_59 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_61 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_28 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW29 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_59 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_61 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_29 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW3 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_169 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_171 PDIFF_173 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_3 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW30 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_81 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_83 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_30 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW31 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_81 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_83 PDIFF_89 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_31 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW32 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_93 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_95 PDIFF_89 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_32 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW33 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_93 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_95 PDIFF_105 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_33 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW34 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_111 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_113 PDIFF_105 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_34 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW35 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_111 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_113 PDIFF_123 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_35 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW36 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_129 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_131 PDIFF_123 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_36 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW37 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_129 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_131 PDIFF_141 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_37 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW38 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_147 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_149 PDIFF_141 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_38 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW39 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_147 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_149 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_39 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_175 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_177 PDIFF_173 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_4 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW40 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_5 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_40 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW41 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_5 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_41 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW42 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_17 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_19 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_42 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW43 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_17 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_19 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_43 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW44 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_37 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_39 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_44 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW45 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_37 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_39 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_45 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW46 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_55 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_57 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_46 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW47 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_55 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_57 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_47 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW48 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_67 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_69 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_48 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW49 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_67 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_69 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_49 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW5 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_175 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_177 PDIFF_179 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_5 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW50 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_97 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_99 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_50 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW51 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_97 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_99 PDIFF_107 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_51 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW52 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_115 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_117 PDIFF_107 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_52 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW53 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_115 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_117 PDIFF_125 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_53 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW54 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_133 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_135 PDIFF_125 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_54 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW55 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_133 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_135 PDIFF_143 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_55 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW56 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_151 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_153 PDIFF_143 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_56 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW57 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_151 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_153 PDIFF_155 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_57 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW58 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_157 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_159 PDIFF_155 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_58 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW59 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_157 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_159 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_59 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW6 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_181 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_183 PDIFF_179 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_6 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW60 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_21 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_23 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_60 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW61 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_21 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_23 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_61 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW62 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_41 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_43 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_62 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW63 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_41 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_43 PDIFF_51 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_63 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW7 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_181 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_183 PDIFF_185 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_7 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
XCC_ROW8 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_187 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_189 PDIFF_185 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_8 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LE
XCC_ROW9 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 MBL DIFF_187 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8
+  GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 NDIFF_189 PDIFF_77 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 TL0_0 TL0_1 TL1 WL_9 VSSE VDDPE VDDCE
+  icache_tag_storeCC_ROW40LO
.ENDS icache_tag_storeCATL40X64TT
****
.SUBCKT icache_tag_storeWDSEC1T64 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AX6N AY0TRACK AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 G0_TIEHIGH_0
+  G0_TIEHIGH_1 G1_TIEHIGH_0 G1_TIEHIGH_1 GTP GTPD GTPDE LGWEN MGDLE MGDLS
+  MGTPE MGTPS RDTN RET RRBTP RREN RXP0 RXP1 RXP2 RXP3 WL0L_0 WL0L_1 WL0L_2
+  WL0L_3 WL0L_4 WL0L_5 WL0L_6 WL0L_7 WL0L_8 WL0L_9 WL0L_10 WL0L_11 WL0L_12
+  WL0L_13 WL0L_14 WL0L_15 WL0L_16 WL0L_17 WL0L_18 WL0L_19 WL0L_20 WL0L_21
+  WL0L_22 WL0L_23 WL0L_24 WL0L_25 WL0L_26 WL0L_27 WL0L_28 WL0L_29 WL0L_30
+  WL0L_31 WL0R_0 WL0R_1 WL0R_2 WL0R_3 WL0R_4 WL0R_5 WL0R_6 WL0R_7 WL0R_8
+  WL0R_9 WL0R_10 WL0R_11 WL0R_12 WL0R_13 WL0R_14 WL0R_15 WL0R_16 WL0R_17
+  WL0R_18 WL0R_19 WL0R_20 WL0R_21 WL0R_22 WL0R_23 WL0R_24 WL0R_25 WL0R_26
+  WL0R_27 WL0R_28 WL0R_29 WL0R_30 WL0R_31 WL1L_0 WL1L_1 WL1L_2 WL1L_3 WL1L_4
+  WL1L_5 WL1L_6 WL1L_7 WL1L_8 WL1L_9 WL1L_10 WL1L_11 WL1L_12 WL1L_13 WL1L_14
+  WL1L_15 WL1L_16 WL1L_17 WL1L_18 WL1L_19 WL1L_20 WL1L_21 WL1L_22 WL1L_23
+  WL1L_24 WL1L_25 WL1L_26 WL1L_27 WL1L_28 WL1L_29 WL1L_30 WL1L_31 WL1R_0
+  WL1R_1 WL1R_2 WL1R_3 WL1R_4 WL1R_5 WL1R_6 WL1R_7 WL1R_8 WL1R_9 WL1R_10
+  WL1R_11 WL1R_12 WL1R_13 WL1R_14 WL1R_15 WL1R_16 WL1R_17 WL1R_18 WL1R_19
+  WL1R_20 WL1R_21 WL1R_22 WL1R_23 WL1R_24 WL1R_25 WL1R_26 WL1R_27 WL1R_28
+  WL1R_29 WL1R_30 WL1R_31 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE
** icache_tag_storeWDSEC1T64: 2248 flat devices **
XBOTTAP AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE XP4 G0_TIEHIGH_1 XP8
+  G1_TIEHIGH_1 GTP GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP
+  RREN RXP0 RXP1 RXP2 RXP3 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWDTAP4
XTOPTAP AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE XP7 G0_TIEHIGH_0 XP9
+  G1_TIEHIGH_0 GTP GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP
+  RREN RXP0 RXP1 RXP2 RXP3 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWDTAP4
XWD1 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP4 XP4 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_0 WL0R_0 WL1L_0 WL1R_0 XP0 XP1 XP2
+  XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD10 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP4 XP5 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_9 WL0R_9 WL1L_9 WL1R_9 XP0 XP1 XP2
+  XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD11 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP5 XP5 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_10 WL0R_10 WL1L_10 WL1R_10 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD12 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP5 XP6 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_11 WL0R_11 WL1L_11 WL1R_11 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD13 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP6 XP6 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_12 WL0R_12 WL1L_12 WL1R_12 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD14 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP6 XP7 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_13 WL0R_13 WL1L_13 WL1R_13 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD15 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP7 XP7 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_14 WL0R_14 WL1L_14 WL1R_14 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD16 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP7 XP4 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_15 WL0R_15 WL1L_15 WL1R_15 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD17 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP4 XP4 XP8 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_16 WL0R_16 WL1L_16 WL1R_16 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD18 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP4 XP5 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_17 WL0R_17 WL1L_17 WL1R_17 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD19 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP5 XP5 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_18 WL0R_18 WL1L_18 WL1R_18 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD2 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP4 XP5 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_1 WL0R_1 WL1L_1 WL1R_1 XP0 XP1 XP2
+  XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD20 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP5 XP6 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_19 WL0R_19 WL1L_19 WL1R_19 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD21 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP6 XP6 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_20 WL0R_20 WL1L_20 WL1R_20 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD22 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP6 XP7 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_21 WL0R_21 WL1L_21 WL1R_21 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD23 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP7 XP7 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_22 WL0R_22 WL1L_22 WL1R_22 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD24 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP7 XP4 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_23 WL0R_23 WL1L_23 WL1R_23 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD25 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP4 XP4 XP9 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_24 WL0R_24 WL1L_24 WL1R_24 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD26 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP4 XP5 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_25 WL0R_25 WL1L_25 WL1R_25 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD27 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP5 XP5 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_26 WL0R_26 WL1L_26 WL1R_26 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD28 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP5 XP6 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_27 WL0R_27 WL1L_27 WL1R_27 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD29 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP6 XP6 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_28 WL0R_28 WL1L_28 WL1R_28 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD3 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP5 XP5 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_2 WL0R_2 WL1L_2 WL1R_2 XP0 XP1 XP2
+  XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD30 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP6 XP7 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_29 WL0R_29 WL1L_29 WL1R_29 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD31 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP7 XP7 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_30 WL0R_30 WL1L_30 WL1R_30 XP0 XP1
+  XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD32 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP1 XP7 XP7 XP9 XP9 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_31 WL0R_31 WL1L_31 WL1R_31 XP0 XP1
+  XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD4 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP5 XP6 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_3 WL0R_3 WL1L_3 WL1R_3 XP0 XP1 XP2
+  XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD5 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP6 XP6 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_4 WL0R_4 WL1L_4 WL1R_4 XP0 XP1 XP2
+  XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD6 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP6 XP7 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_5 WL0R_5 WL1L_5 WL1R_5 XP0 XP1 XP2
+  XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD7 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP7 XP7 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_6 WL0R_6 WL1L_6 WL1R_6 XP0 XP1 XP2
+  XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD8 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP7 XP4 XP8 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_7 WL0R_7 WL1L_7 WL1R_7 XP0 XP1 XP2
+  XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
XWD9 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 VSSE VSSE BTP0 XP4 XP4 XP9 XP8 GTP GTPD
+  GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP RRBTP RRBTP RREN RXP0
+  RXP0 RXP1 RXP1 RXP2 RXP2 RXP3 RXP3 WL0L_8 WL0R_8 WL1L_8 WL1R_8 XP0 XP1 XP2
+  XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeWD4
.ENDS icache_tag_storeWDSEC1T64
****
.SUBCKT icache_tag_storeCATR44X64TT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31
+  BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41
+  BL__42 BL__43 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 MBL PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL_63 VSSE VDDPE VDDCE
** icache_tag_storeCATR44X64TT: 17280 flat devices **
XCC_ROW0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_161
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_163 PDIFF_165 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_0 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_161
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_163 PDIFF_167 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_1 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW10 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_73
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_75 PDIFF_77 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_10 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW11 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_73
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_75 PDIFF_79 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_11 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW12 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_85
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_87 PDIFF_79 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_12 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW13 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_85
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_87 PDIFF_91 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_13 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_101
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_103 PDIFF_91 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_14 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_101
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_103 PDIFF_109 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_15 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW16 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_119
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_121 PDIFF_109 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_16 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW17 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_119
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_121 PDIFF_127 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_17 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW18 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_137
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_139 PDIFF_127 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_18 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW19 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_137
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_139 PDIFF_145 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_19 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW2 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_169
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_171 PDIFF_167 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_2 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW20 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF PDIFF_145 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_20 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW21 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6
+  PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17
+  PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27
+  PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37
+  PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1 WL_21 VSSE
+  VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW22 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_9
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_11 PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_22 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW23 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_9
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_11 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_23 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW24 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_27
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_29 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_24 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW25 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_27
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_29 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_25 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW26 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_45
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_47 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_26 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW27 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_45
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_47 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_27 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW28 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_59
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_61 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_28 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW29 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_59
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_61 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_29 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW3 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_169
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_171 PDIFF_173 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_3 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW30 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_81
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_83 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_30 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW31 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_81
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_83 PDIFF_89 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_31 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW32 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_93
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_95 PDIFF_89 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_32 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW33 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_93
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_95 PDIFF_105 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_33 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW34 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_111
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_113 PDIFF_105 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_34 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW35 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_111
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_113 PDIFF_123 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_35 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW36 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_129
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_131 PDIFF_123 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_36 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW37 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_129
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_131 PDIFF_141 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_37 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW38 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_147
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_149 PDIFF_141 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_38 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW39 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_147
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_149 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_39 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_175
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_177 PDIFF_173 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_4 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW40 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_3
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_5 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_40 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW41 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_3
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_5 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_41 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW42 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_17
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_19 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_42 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW43 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_17
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_19 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_43 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW44 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_37
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_39 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_44 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW45 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_37
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_39 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_45 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW46 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_55
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_57 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_46 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW47 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_55
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_57 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_47 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW48 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_67
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_69 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_48 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW49 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_67
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_69 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_49 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW5 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_175
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_177 PDIFF_179 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_5 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW50 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_97
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_99 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_50 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW51 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_97
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_99 PDIFF_107 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_51 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW52 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_115
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_117 PDIFF_107 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_52 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW53 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_115
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_117 PDIFF_125 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_53 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW54 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_133
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_135 PDIFF_125 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_54 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW55 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_133
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_135 PDIFF_143 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_55 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW56 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_151
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_153 PDIFF_143 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_56 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW57 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_151
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_153 PDIFF_155 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_57 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW58 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_157
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_159 PDIFF_155 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_58 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW59 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_157
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_159 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_59 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW6 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_181
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_183 PDIFF_179 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_6 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW60 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_21
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_23 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_60 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW61 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_21
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_23 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_61 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW62 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_41
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_43 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_62 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW63 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_41
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_43 PDIFF_51 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_63 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW7 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_181
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_183 PDIFF_185 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_7 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
XCC_ROW8 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_187
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_189 PDIFF_185 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4
+  PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15
+  PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25
+  PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35
+  PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1
+  TL1 WL_8 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RE
XCC_ROW9 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34
+  BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 MBL DIFF_187
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 NDIFF_189 PDIFF_77 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 TL0_0 TL0_1 TL1
+  WL_9 VSSE VDDPE VDDCE icache_tag_storeCC_ROW44RO
.ENDS icache_tag_storeCATR44X64TT
****
.SUBCKT icache_tag_storeBK1T21X64 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AX6N AY0TRACK AY1TRACK AY2TRACK BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19
+  BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31
+  BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43
+  BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55
+  BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67
+  BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79
+  BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BS0 BS1 BTP0 BTP1
+  G0_TIEHIGH_0 G0_TIEHIGH_1 G1_TIEHIGH_0 G1_TIEHIGH_1 GDL_0 GDL_1 GDL_2 GDL_3
+  GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24
+  GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34
+  GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44
+  GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54
+  GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64
+  GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74
+  GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84
+  GDL_85 GTP GTPD GTPDE LGWEN MBL_0 MBL_1 MGDLE MGDLS MGTPE MGTPS PG0_0 PG0_1
+  PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13
+  PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23
+  PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33
+  PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43
+  PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53
+  PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63
+  PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73
+  PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83
+  PG0_84 PG0_85 RDTN RET RRBTP RREN RXP0 RXP1 RXP2 RXP3 TL0_0 TL0_1 TL0_2
+  TL0_3 TL1_0 TL1_1 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE
+  VDDPE VDDCE
** icache_tag_storeBK1T21X64: 35272 flat devices **
XLEFTCOREBANK1 BL_40 BL_39 BL_38 BL_37 BL_36 BL_35 BL_34 BL_33 BL_32 BL_31
+  BL_30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL_22 BL_21 BL_20 BL_19
+  BL_18 BL_17 BL_16 BL_15 BL_14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL_6
+  BL_5 BL_4 BL_3 BL_2 BL_1 BL_0 BL__39 BL__38 BL__37 BL__36 BL__35 BL__34
+  BL__33 BL__32 BL__31 BL__30 BL__29 BL__28 BL__27 BL__26 BL__25 BL__24
+  BL__23 BL__22 BL__21 BL__20 BL__19 BL__18 BL__17 BL__16 BL__15 BL__14
+  BL__13 BL__12 BL__11 BL__10 BL__9 BL__8 BL__7 BL__6 BL__5 BL__4 BL__3 BL__2
+  BL__1 BL__0 GDL_40 GDL_39 GDL_38 GDL_37 GDL_36 GDL_35 GDL_34 GDL_33 GDL_32
+  GDL_31 GDL_30 GDL_29 GDL_28 GDL_27 GDL_26 GDL_25 GDL_24 GDL_23 GDL_22
+  GDL_21 GDL_20 GDL_19 GDL_18 GDL_17 GDL_16 GDL_15 GDL_14 GDL_13 GDL_12
+  GDL_11 GDL_10 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5 GDL_4 GDL_3 GDL_2 GDL_1 GDL_0
+  MBL_0 PG0_40 PG0_39 PG0_38 PG0_37 PG0_36 PG0_35 PG0_34 PG0_33 PG0_32 PG0_31
+  PG0_30 PG0_29 PG0_28 PG0_27 PG0_26 PG0_25 PG0_24 PG0_23 PG0_22 PG0_21
+  PG0_20 PG0_19 PG0_18 PG0_17 PG0_16 PG0_15 PG0_14 PG0_13 PG0_12 PG0_11
+  PG0_10 PG0_9 PG0_8 PG0_7 PG0_6 PG0_5 PG0_4 PG0_3 PG0_2 PG0_1 PG0_0 TL0_1
+  TL0_0 TL1_0 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 WL_63 VSSE VDDPE VDDCE icache_tag_storeCATL40X64TT
XRIGHTCOREBANK1 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50
+  BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62
+  BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74
+  BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47
+  GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57
+  GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67
+  GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77
+  GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 MBL_1 PG0_41 PG0_42
+  PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52
+  PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62
+  PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72
+  PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82
+  PG0_83 PG0_84 PG0_85 TL0_2 TL0_3 TL1_1 WL0R_0 WL1R_0 WL1R_1 WL0R_1 WL0R_2
+  WL1R_2 WL1R_3 WL0R_3 WL0R_4 WL1R_4 WL1R_5 WL0R_5 WL0R_6 WL1R_6 WL1R_7
+  WL0R_7 WL0R_8 WL1R_8 WL1R_9 WL0R_9 WL0R_10 WL1R_10 WL1R_11 WL0R_11 WL0R_12
+  WL1R_12 WL1R_13 WL0R_13 WL0R_14 WL1R_14 WL1R_15 WL0R_15 WL0R_16 WL1R_16
+  WL1R_17 WL0R_17 WL0R_18 WL1R_18 WL1R_19 WL0R_19 WL0R_20 WL1R_20 WL1R_21
+  WL0R_21 WL0R_22 WL1R_22 WL1R_23 WL0R_23 WL0R_24 WL1R_24 WL1R_25 WL0R_25
+  WL0R_26 WL1R_26 WL1R_27 WL0R_27 WL0R_28 WL1R_28 WL1R_29 WL0R_29 WL0R_30
+  WL1R_30 WL1R_31 WL0R_31 VSSE VDDPE VDDCE icache_tag_storeCATR44X64TT
XWDBANK1 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AX6N AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 G0_TIEHIGH_0 G0_TIEHIGH_1 G1_TIEHIGH_0
+  G1_TIEHIGH_1 GTP GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP
+  RREN RXP0 RXP1 RXP2 RXP3 WL_0 WL_3 WL_4 WL_7 WL_8 WL_11 WL_12 WL_15 WL_16
+  WL_19 WL_20 WL_23 WL_24 WL_27 WL_28 WL_31 WL_32 WL_35 WL_36 WL_39 WL_40
+  WL_43 WL_44 WL_47 WL_48 WL_51 WL_52 WL_55 WL_56 WL_59 WL_60 WL_63 WL0R_0
+  WL0R_1 WL0R_2 WL0R_3 WL0R_4 WL0R_5 WL0R_6 WL0R_7 WL0R_8 WL0R_9 WL0R_10
+  WL0R_11 WL0R_12 WL0R_13 WL0R_14 WL0R_15 WL0R_16 WL0R_17 WL0R_18 WL0R_19
+  WL0R_20 WL0R_21 WL0R_22 WL0R_23 WL0R_24 WL0R_25 WL0R_26 WL0R_27 WL0R_28
+  WL0R_29 WL0R_30 WL0R_31 WL_1 WL_2 WL_5 WL_6 WL_9 WL_10 WL_13 WL_14 WL_17
+  WL_18 WL_21 WL_22 WL_25 WL_26 WL_29 WL_30 WL_33 WL_34 WL_37 WL_38 WL_41
+  WL_42 WL_45 WL_46 WL_49 WL_50 WL_53 WL_54 WL_57 WL_58 WL_61 WL_62 WL1R_0
+  WL1R_1 WL1R_2 WL1R_3 WL1R_4 WL1R_5 WL1R_6 WL1R_7 WL1R_8 WL1R_9 WL1R_10
+  WL1R_11 WL1R_12 WL1R_13 WL1R_14 WL1R_15 WL1R_16 WL1R_17 WL1R_18 WL1R_19
+  WL1R_20 WL1R_21 WL1R_22 WL1R_23 WL1R_24 WL1R_25 WL1R_26 WL1R_27 WL1R_28
+  WL1R_29 WL1R_30 WL1R_31 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE icache_tag_storeWDSEC1T64
.ENDS icache_tag_storeBK1T21X64
****
.SUBCKT icache_tag_storeBH512X21M4 AX0TRACK_0 AX0TRACK_1 AX1TRACK_0 AX1TRACK_1
+  AX2TRACK_0 AX2TRACK_1 AX3TRACK_0 AX3TRACK_1 AX4TRACK_0 AX4TRACK_1
+  AX5TRACK_0 AX5TRACK_1 AX6N AY0TRACK_0 AY0TRACK_1 AY1TRACK_0 AY1TRACK_1
+  AY2TRACK_0 AY2TRACK_1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9
+  BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21
+  BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33
+  BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45
+  BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57
+  BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69
+  BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81
+  BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93
+  BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104
+  BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114
+  BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124
+  BL_125 BL_126 BL_127 BL_128 BL_129 BL_130 BL_131 BL_132 BL_133 BL_134
+  BL_135 BL_136 BL_137 BL_138 BL_139 BL_140 BL_141 BL_142 BL_143 BL_144
+  BL_145 BL_146 BL_147 BL_148 BL_149 BL_150 BL_151 BL_152 BL_153 BL_154
+  BL_155 BL_156 BL_157 BL_158 BL_159 BL_160 BL_161 BL_162 BL_163 BL_164
+  BL_165 BL_166 BL_167 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8
+  BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29
+  BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39
+  BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49
+  BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59
+  BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69
+  BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79
+  BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89
+  BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99
+  BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108
+  BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117
+  BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126
+  BL__127 BL__128 BL__129 BL__130 BL__131 BL__132 BL__133 BL__134 BL__135
+  BL__136 BL__137 BL__138 BL__139 BL__140 BL__141 BL__142 BL__143 BL__144
+  BL__145 BL__146 BL__147 BL__148 BL__149 BL__150 BL__151 BL__152 BL__153
+  BL__154 BL__155 BL__156 BL__157 BL__158 BL__159 BL__160 BL__161 BL__162
+  BL__163 BL__164 BL__165 BL__166 BL__167 BS0 BS1 BTP0 BTP1 G0_TIEHIGH
+  G1_TIEHIGH GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49
+  GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59
+  GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69
+  GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79
+  GDL_80 GDL_81 GDL_82 GDL_83 GTPD GTP_0 GTP_1 LGWEN MBL_0 MBL_1 MBL_2 MGTPE
+  MGTPS MWLLATE RDTN RET RREN_0 RREN_1 RXP0_0 RXP0_1 RXP1_0 RXP1_1 RXP2_0
+  RXP2_1 RXP3_0 RXP3_1 STUBMATCH0 TL0_0 TL0_1 TL0_2 TL0_3 WBT XP0 XP1 XP2 XP3
+  XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
** icache_tag_storeBH512X21M4: 75740 flat devices **
XBANK0 AX0TRACK_1 AX1TRACK_1 AX2TRACK_1 AX3TRACK_1 AX4TRACK_1 AX5TRACK_1 AX6N
+  AY0TRACK_1 AY1TRACK_1 AY2TRACK_1 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 VSSE VSSE BL_124 BL_125 BL_126 BL_127 BL_128 BL_129 BL_130 BL_131
+  BL_132 BL_133 BL_134 BL_135 BL_136 BL_137 BL_138 BL_139 BL_140 BL_141
+  BL_142 BL_143 BL_144 BL_145 BL_146 BL_147 BL_148 BL_149 BL_150 BL_151
+  BL_152 BL_153 BL_154 BL_155 BL_156 BL_157 BL_158 BL_159 BL_160 BL_161
+  BL_162 BL_163 BL_164 BL_165 BL_166 BL_167 BL__84 BL__85 BL__86 BL__87
+  BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97
+  BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106
+  BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115
+  BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124
+  BL__125 BL__126 BL__127 BL__128 BL__129 BL__130 BL__131 BL__132 BL__133
+  BL__134 BL__135 BL__136 BL__137 BL__138 BL__139 BL__140 BL__141 BL__142
+  BL__143 BL__144 BL__145 BL__146 BL__147 BL__148 BL__149 BL__150 BL__151
+  BL__152 BL__153 BL__154 BL__155 BL__156 BL__157 BL__158 BL__159 BL__160
+  BL__161 BL__162 BL__163 BL__164 BL__165 BL__166 BL__167 BS0 BS1 BTPWDB0
+  BTPWDB1 TIEHIGHB TIEHIGHB VSSE GDL_42 GDL_43 VDDCE VDDCE GDL_44 GDL_45 VSSE
+  VSSE GDL_46 GDL_47 VDDCE VDDCE GDL_48 GDL_49 VSSE VSSE GDL_50 GDL_51 VDDCE
+  VDDCE GDL_52 GDL_53 VSSE VSSE GDL_54 GDL_55 VDDCE VDDCE GDL_56 GDL_57 VSSE
+  VSSE GDL_58 GDL_59 VDDCE VDDCE GDL_60 GDL_61 VSSE VSSE VSSE VSSE GDL_62
+  GDL_63 VDDCE VDDCE GDL_64 GDL_65 VSSE VSSE GDL_66 GDL_67 VDDCE VDDCE GDL_68
+  GDL_69 VSSE VSSE GDL_70 GDL_71 VDDCE VDDCE GDL_72 GDL_73 VSSE VSSE GDL_74
+  GDL_75 VDDCE VDDCE GDL_76 GDL_77 VSSE VSSE GDL_78 GDL_79 VDDCE VDDCE GDL_80
+  GDL_81 VSSE VSSE GDL_82 GDL_83 VDDCE GTP_1 GTPD GTPD RET LGWEN MBL_2 MBL_1
+  MBL_1 MGTPS MGTPS MWLLATE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE
+  VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE
+  VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE
+  VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VSSE VSSE VDDPE VDDCE VDDPE VDDPE
+  VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE
+  VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE
+  VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE
+  RDTN RREN_1 RXP0_1 RXP0_0 RXP1_1 RXP1_0 RXP2_1 RXP2_0 RXP3_1 RXP3_0
+  STUBMATCH0 TL0_2 STUBMATCH0 MBL_1 TL0_3 TL0_2 TL0_3 WBT XP0 XP1 XP2 XP3 XP4
+  XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE icache_tag_storeBK0B21X64
XBANK1 AX0TRACK_0 AX1TRACK_0 AX2TRACK_0 AX3TRACK_0 AX4TRACK_0 AX5TRACK_0 AX6N
+  AY0TRACK_0 AY1TRACK_0 AY2TRACK_0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 VSSE VSSE BL_40 BL_41 BL_42 BL_43
+  BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55
+  BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67
+  BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79
+  BL_80 BL_81 BL_82 BL_83 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BS0 BS1 BTP0 BTP1 G0_TIEHIGH TIEHIGHT
+  G1_TIEHIGH TIEHIGHT VSSE GDL_0 GDL_1 VDDCE VDDCE GDL_2 GDL_3 VSSE VSSE
+  GDL_4 GDL_5 VDDCE VDDCE GDL_6 GDL_7 VSSE VSSE GDL_8 GDL_9 VDDCE VDDCE
+  GDL_10 GDL_11 VSSE VSSE GDL_12 GDL_13 VDDCE VDDCE GDL_14 GDL_15 VSSE VSSE
+  GDL_16 GDL_17 VDDCE VDDCE GDL_18 GDL_19 VSSE VSSE VSSE VSSE GDL_20 GDL_21
+  VDDCE VDDCE GDL_22 GDL_23 VSSE VSSE GDL_24 GDL_25 VDDCE VDDCE GDL_26 GDL_27
+  VSSE VSSE GDL_28 GDL_29 VDDCE VDDCE GDL_30 GDL_31 VSSE VSSE GDL_32 GDL_33
+  VDDCE VDDCE GDL_34 GDL_35 VSSE VSSE GDL_36 GDL_37 VDDCE VDDCE GDL_38 GDL_39
+  VSSE VSSE GDL_40 GDL_41 VDDCE GTP_0 GTPD GTPD LGWEN MBL_0 MBL_1 MBL_1 MBL_1
+  MGTPE MBL_1 VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE
+  VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE
+  VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE
+  VDDCE VDDPE VSSE VSSE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE
+  VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE
+  VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE
+  VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE RDTN RET VSSE
+  RREN_0 RXP0_0 RXP1_0 RXP2_0 RXP3_0 TL0_0 MBL_0 MBL_1 TL0_1 TL0_0 TL0_1 XP0
+  XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  icache_tag_storeBK1T21X64
XCHANNEL0 AX0TRACK_1 AX0TRACK_0 AX1TRACK_1 AX1TRACK_0 AX2TRACK_1 AX2TRACK_0
+  AX3TRACK_1 AX3TRACK_0 AX4TRACK_1 AX4TRACK_0 AX5TRACK_1 AX5TRACK_0 AX6N
+  AY0TRACK_1 AY0TRACK_0 AY1TRACK_1 AY1TRACK_0 AY2TRACK_1 AY2TRACK_0 BL_0 BL_7
+  BL_8 BL_15 BL_16 BL_23 BL_24 BL_31 BL_32 BL_39 BL_40 BL_47 BL_48 BL_55
+  BL_56 BL_63 BL_64 BL_71 BL_72 BL_79 BL_80 BL_84 BL_91 BL_92 BL_99 BL_100
+  BL_107 BL_108 BL_115 BL_116 BL_123 BL_124 BL_131 BL_132 BL_139 BL_140
+  BL_147 BL_148 BL_155 BL_156 BL_163 BL_164 BL__0 BL__7 BL__8 BL__15 BL__16
+  BL__23 BL__24 BL__31 BL__32 BL__39 BL__40 BL__47 BL__48 BL__55 BL__56
+  BL__63 BL__64 BL__71 BL__72 BL__79 BL__80 BL__84 BL__91 BL__92 BL__99
+  BL__100 BL__107 BL__108 BL__115 BL__116 BL__123 BL__124 BL__131 BL__132
+  BL__139 BL__140 BL__147 BL__148 BL__155 BL__156 BL__163 BL__164 BL_1 BL_6
+  BL_9 BL_14 BL_17 BL_22 BL_25 BL_30 BL_33 BL_38 BL_41 BL_46 BL_49 BL_54
+  BL_57 BL_62 BL_65 BL_70 BL_73 BL_78 BL_81 BL_85 BL_90 BL_93 BL_98 BL_101
+  BL_106 BL_109 BL_114 BL_117 BL_122 BL_125 BL_130 BL_133 BL_138 BL_141
+  BL_146 BL_149 BL_154 BL_157 BL_162 BL_165 BL__1 BL__6 BL__9 BL__14 BL__17
+  BL__22 BL__25 BL__30 BL__33 BL__38 BL__41 BL__46 BL__49 BL__54 BL__57
+  BL__62 BL__65 BL__70 BL__73 BL__78 BL__81 BL__85 BL__90 BL__93 BL__98
+  BL__101 BL__106 BL__109 BL__114 BL__117 BL__122 BL__125 BL__130 BL__133
+  BL__138 BL__141 BL__146 BL__149 BL__154 BL__157 BL__162 BL__165 BL_2 BL_5
+  BL_10 BL_13 BL_18 BL_21 BL_26 BL_29 BL_34 BL_37 BL_42 BL_45 BL_50 BL_53
+  BL_58 BL_61 BL_66 BL_69 BL_74 BL_77 BL_82 BL_86 BL_89 BL_94 BL_97 BL_102
+  BL_105 BL_110 BL_113 BL_118 BL_121 BL_126 BL_129 BL_134 BL_137 BL_142
+  BL_145 BL_150 BL_153 BL_158 BL_161 BL_166 BL__2 BL__5 BL__10 BL__13 BL__18
+  BL__21 BL__26 BL__29 BL__34 BL__37 BL__42 BL__45 BL__50 BL__53 BL__58
+  BL__61 BL__66 BL__69 BL__74 BL__77 BL__82 BL__86 BL__89 BL__94 BL__97
+  BL__102 BL__105 BL__110 BL__113 BL__118 BL__121 BL__126 BL__129 BL__134
+  BL__137 BL__142 BL__145 BL__150 BL__153 BL__158 BL__161 BL__166 BL_3 BL_4
+  BL_11 BL_12 BL_19 BL_20 BL_27 BL_28 BL_35 BL_36 BL_43 BL_44 BL_51 BL_52
+  BL_59 BL_60 BL_67 BL_68 BL_75 BL_76 BL_83 BL_87 BL_88 BL_95 BL_96 BL_103
+  BL_104 BL_111 BL_112 BL_119 BL_120 BL_127 BL_128 BL_135 BL_136 BL_143
+  BL_144 BL_151 BL_152 BL_159 BL_160 BL_167 BL__3 BL__4 BL__11 BL__12 BL__19
+  BL__20 BL__27 BL__28 BL__35 BL__36 BL__43 BL__44 BL__51 BL__52 BL__59
+  BL__60 BL__67 BL__68 BL__75 BL__76 BL__83 BL__87 BL__88 BL__95 BL__96
+  BL__103 BL__104 BL__111 BL__112 BL__119 BL__120 BL__127 BL__128 BL__135
+  BL__136 BL__143 BL__144 BL__151 BL__152 BL__159 BL__160 BL__167 BS0 BS1
+  VSSE VSSE VSSE VSSE BTPWDB0 BTPWDB1 BTP0 BTP1 GDL_0 GDL_3 GDL_4 GDL_7 GDL_8
+  GDL_11 GDL_12 GDL_15 GDL_16 GDL_19 GDL_20 GDL_23 GDL_24 GDL_27 GDL_28
+  GDL_31 GDL_32 GDL_35 GDL_36 GDL_39 GDL_40 GDL_42 GDL_45 GDL_46 GDL_49
+  GDL_50 GDL_53 GDL_54 GDL_57 GDL_58 GDL_61 GDL_62 GDL_65 GDL_66 GDL_69
+  GDL_70 GDL_73 GDL_74 GDL_77 GDL_78 GDL_81 GDL_82 GDL_1 GDL_2 GDL_5 GDL_6
+  GDL_9 GDL_10 GDL_13 GDL_14 GDL_17 GDL_18 GDL_21 GDL_22 GDL_25 GDL_26 GDL_29
+  GDL_30 GDL_33 GDL_34 GDL_37 GDL_38 GDL_41 GDL_43 GDL_44 GDL_47 GDL_48
+  GDL_51 GDL_52 GDL_55 GDL_56 GDL_59 GDL_60 GDL_63 GDL_64 GDL_67 GDL_68
+  GDL_71 GDL_72 GDL_75 GDL_76 GDL_79 GDL_80 GDL_83 GTP_1 GTPD GTP_0 LGWEN
+  MBL_2 MBL_1 MGTPS MGTPE RDTN RET RREN_1 RREN_0 RXP0_0 RXP1_0 RXP2_0 RXP3_0
+  TIEHIGHB TIEHIGHT STUBMATCH0 MBL_0 TL0_0 TL0_1 TL0_2 TL0_3 XP1 XP0 XP3 XP2
+  XP5 XP4 XP7 XP6 XP9 XP8 XP11 XP10 VSSE VDDPE VDDCE
+  icache_tag_storeCHB0_21M4BT
.ENDS icache_tag_storeBH512X21M4
****
.SUBCKT icache_tag_storeF512X21M4B1 AI0 AI1 AI5 AI6 AI7 AI8 AI9 AI10 AI11 AI12
+  BWEN_0 BWEN_1 BWEN_2 BWEN_3 BWEN_4 BWEN_5 BWEN_6 BWEN_7 BWEN_8 BWEN_9
+  BWEN_10 BWEN_11 BWEN_12 BWEN_13 BWEN_14 BWEN_15 BWEN_16 BWEN_17 BWEN_18
+  BWEN_19 BWEN_20 CEN CLK CREN D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10
+  D_11 D_12 D_13 D_14 D_15 D_16 D_17 D_18 D_19 D_20 EMA0 EMA1 EMA2 Q_0 Q_1
+  Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 Q_16 Q_17
+  Q_18 Q_19 Q_20 RETN WEN VSSE VDDPE VDDCE
** icache_tag_storeF512X21M4B1: 80338 flat devices **
XFPIOROW AI0 AI0N AI1 AI1N AI2N AI3N AI4N AI5 AI5N AI6 AI6N AI7 AI7N AI8 AI8N
+  AI9 AI9N AI10 AI10N AI11 AI11N AI12N AI13N BWEI_0 BWEI_1 BWEI_2 BWEI_3
+  BWEI_4 BWEI_5 BWEI_6 BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12 BWEI_13
+  BWEI_14 BWEI_15 BWEI_16 BWEI_17 BWEI_18 BWEI_19 BWEI_20 BWEN_0 BWEN_1
+  BWEN_2 BWEN_3 BWEN_4 BWEN_5 BWEN_6 BWEN_7 BWEN_8 BWEN_9 BWEN_10 BWEN_11
+  BWEN_12 BWEN_13 BWEN_14 BWEN_15 BWEN_16 BWEN_17 BWEN_18 BWEN_19 BWEN_20 CEI
+  CEN CLK CREN DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9
+  DNI_10 DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 DNI_16 DNI_17 DNI_18 DNI_19
+  DNI_20 D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14
+  D_15 D_16 D_17 D_18 D_19 D_20 EMA0 EMA1 EMA2 RET_20 RETN_TERM_20 Q_0 Q_1
+  Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 Q_16 Q_17
+  Q_18 Q_19 Q_20 Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9 Q__10
+  Q__11 Q__12 Q__13 Q__14 Q__15 Q__16 Q__17 Q__18 Q__19 Q__20 RETN
+  RETN_TERM_20 RETN_TERM_20 RETN_TERM_20 RETN_TERM_20 RETN_TERM_20
+  RETN_TERM_20 RETN_TERM_20 RETN_TERM_20 RETN_TERM_20 RETN_TERM_20
+  RETN_TERM_20 RETN_TERM_20 RETN_TERM_20 RETN_TERM_20 RETN_TERM_20
+  RETN_TERM_20 RETN_TERM_20 RETN_TERM_20 RETN_TERM_20 RETN_TERM_20
+  RETN_TERM_20 RET_20 RET_20 RET_20 RET_20 RET_20 RET_20 RET_20 RET_20 RET_20
+  RET_20 RET_20 RET_20 RET_20 RET_20 RET_20 RET_20 RET_20 RET_20 RET_20
+  RET_20 RET_20 AI12 WEI WEN VSSE VDDPE VDDCE icache_tag_storeBR21FPIO8B1
XHALF_MEM VSSE AX0N VSSE AX1N VSSE AX2N VSSE AX3N VSSE AX4N VSSE AX5N
+  AX6N_TERM VSSE AY0N VSSE AY1N VSSE AY2N BL0_0 BL1_0 BL2_0 BL3_0 BL3_1 BL2_1
+  BL1_1 BL0_1 BL0_2 BL1_2 BL2_2 BL3_2 BL3_3 BL2_3 BL1_3 BL0_3 BL0_4 BL1_4
+  BL2_4 BL3_4 BL3_5 BL2_5 BL1_5 BL0_5 BL0_6 BL1_6 BL2_6 BL3_6 BL3_7 BL2_7
+  BL1_7 BL0_7 BL0_8 BL1_8 BL2_8 BL3_8 BL3_9 BL2_9 BL1_9 BL0_9 BL0_10 BL1_10
+  BL2_10 BL3_10 BL3_11 BL2_11 BL1_11 BL0_11 BL0_12 BL1_12 BL2_12 BL3_12
+  BL3_13 BL2_13 BL1_13 BL0_13 BL0_14 BL1_14 BL2_14 BL3_14 BL3_15 BL2_15
+  BL1_15 BL0_15 BL0_16 BL1_16 BL2_16 BL3_16 BL3_17 BL2_17 BL1_17 BL0_17
+  BL0_18 BL1_18 BL2_18 BL3_18 BL3_19 BL2_19 BL1_19 BL0_19 BL0_20 BL1_20
+  BL2_20 BL3_20 BLTERM0_0 BLTERM1__0 BLTERM2_0 BLTERM3__0 BLTERM3__1
+  BLTERM2_1 BLTERM1__1 BLTERM0_1 BLTERM0_2 BLTERM1__2 BLTERM2_2 BLTERM3__2
+  BLTERM3__3 BLTERM2_3 BLTERM1__3 BLTERM0_3 BLTERM0_4 BLTERM1__4 BLTERM2_4
+  BLTERM3__4 BLTERM3__5 BLTERM2_5 BLTERM1__5 BLTERM0_5 BLTERM0_6 BLTERM1__6
+  BLTERM2_6 BLTERM3__6 BLTERM3__7 BLTERM2_7 BLTERM1__7 BLTERM0_7 BLTERM0_8
+  BLTERM1__8 BLTERM2_8 BLTERM3__8 BLTERM3__9 BLTERM2_9 BLTERM1__9 BLTERM0_9
+  BLTERM0_10 BLTERM1__10 BLTERM2_10 BLTERM3__10 BLTERM3__11 BLTERM2_11
+  BLTERM1__11 BLTERM0_11 BLTERM0_12 BLTERM1__12 BLTERM2_12 BLTERM3__12
+  BLTERM3__13 BLTERM2_13 BLTERM1__13 BLTERM0_13 BLTERM0_14 BLTERM1__14
+  BLTERM2_14 BLTERM3__14 BLTERM3__15 BLTERM2_15 BLTERM1__15 BLTERM0_15
+  BLTERM0_16 BLTERM1__16 BLTERM2_16 BLTERM3__16 BLTERM3__17 BLTERM2_17
+  BLTERM1__17 BLTERM0_17 BLTERM0_18 BLTERM1__18 BLTERM2_18 BLTERM3__18
+  BLTERM3__19 BLTERM2_19 BLTERM1__19 BLTERM0_19 BLTERM0_20 BLTERM1__20
+  BLTERM2_20 BLTERM3__20 BL0__0 BL1__0 BL2__0 BL3__0 BL3__1 BL2__1 BL1__1
+  BL0__1 BL0__2 BL1__2 BL2__2 BL3__2 BL3__3 BL2__3 BL1__3 BL0__3 BL0__4
+  BL1__4 BL2__4 BL3__4 BL3__5 BL2__5 BL1__5 BL0__5 BL0__6 BL1__6 BL2__6
+  BL3__6 BL3__7 BL2__7 BL1__7 BL0__7 BL0__8 BL1__8 BL2__8 BL3__8 BL3__9
+  BL2__9 BL1__9 BL0__9 BL0__10 BL1__10 BL2__10 BL3__10 BL3__11 BL2__11
+  BL1__11 BL0__11 BL0__12 BL1__12 BL2__12 BL3__12 BL3__13 BL2__13 BL1__13
+  BL0__13 BL0__14 BL1__14 BL2__14 BL3__14 BL3__15 BL2__15 BL1__15 BL0__15
+  BL0__16 BL1__16 BL2__16 BL3__16 BL3__17 BL2__17 BL1__17 BL0__17 BL0__18
+  BL1__18 BL2__18 BL3__18 BL3__19 BL2__19 BL1__19 BL0__19 BL0__20 BL1__20
+  BL2__20 BL3__20 BLTERM0__0 BLTERM1_0 BLTERM2__0 BLTERM3_0 BLTERM3_1
+  BLTERM2__1 BLTERM1_1 BLTERM0__1 BLTERM0__2 BLTERM1_2 BLTERM2__2 BLTERM3_2
+  BLTERM3_3 BLTERM2__3 BLTERM1_3 BLTERM0__3 BLTERM0__4 BLTERM1_4 BLTERM2__4
+  BLTERM3_4 BLTERM3_5 BLTERM2__5 BLTERM1_5 BLTERM0__5 BLTERM0__6 BLTERM1_6
+  BLTERM2__6 BLTERM3_6 BLTERM3_7 BLTERM2__7 BLTERM1_7 BLTERM0__7 BLTERM0__8
+  BLTERM1_8 BLTERM2__8 BLTERM3_8 BLTERM3_9 BLTERM2__9 BLTERM1_9 BLTERM0__9
+  BLTERM0__10 BLTERM1_10 BLTERM2__10 BLTERM3_10 BLTERM3_11 BLTERM2__11
+  BLTERM1_11 BLTERM0__11 BLTERM0__12 BLTERM1_12 BLTERM2__12 BLTERM3_12
+  BLTERM3_13 BLTERM2__13 BLTERM1_13 BLTERM0__13 BLTERM0__14 BLTERM1_14
+  BLTERM2__14 BLTERM3_14 BLTERM3_15 BLTERM2__15 BLTERM1_15 BLTERM0__15
+  BLTERM0__16 BLTERM1_16 BLTERM2__16 BLTERM3_16 BLTERM3_17 BLTERM2__17
+  BLTERM1_17 BLTERM0__17 BLTERM0__18 BLTERM1_18 BLTERM2__18 BLTERM3_18
+  BLTERM3_19 BLTERM2__19 BLTERM1_19 BLTERM0__19 BLTERM0__20 BLTERM1_20
+  BLTERM2__20 BLTERM3_20 BS0_TERM BS1_TERM BTP0 BTP1 TIEHIGH TIEHIGH VSSE
+  VDDCE VDDCE VSSE VSSE VDDCE VDDCE VSSE VSSE VDDCE VDDCE VSSE VSSE VDDCE
+  VDDCE VSSE VSSE VDDCE VDDCE VSSE VSSE VDDCE VDDCE VSSE VSSE VDDCE VDDCE
+  VSSE VSSE VDDCE VDDCE VSSE VSSE VDDCE VDDCE VSSE VSSE VDDCE VDDCE VSSE VSSE
+  VDDCE GDL_0 GDL__0 GDL__1 GDL_1 GDL_2 GDL__2 GDL__3 GDL_3 GDL_4 GDL__4
+  GDL__5 GDL_5 GDL_6 GDL__6 GDL__7 GDL_7 GDL_8 GDL__8 GDL__9 GDL_9 GDL_10
+  GDL__10 GDL__11 GDL_11 GDL_12 GDL__12 GDL__13 GDL_13 GDL_14 GDL__14 GDL__15
+  GDL_15 GDL_16 GDL__16 GDL__17 GDL_17 GDL_18 GDL__18 GDL__19 GDL_19 GDL_20
+  GDL__20 GTPD VSSE GTP LGWEN MBL_TERM_0 TL0_TERM_1 MBL VSSE MGTPS MWLLATE
+  RDTN RET_20 VSSE RRENDD VSSE RXP0 VSSE RXP1 VSSE RXP2 VSSE RXP3 MATCH0
+  TIELOW_0 TIELOW_1 AI12 AI12 WBTDD XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9
+  XP10 XP11 VSSE VDDPE VDDCE icache_tag_storeBH512X21M4
XIOROW AI0N AI1N AI2N AI3N AI4N AI5N AI6N AI7N AI8N AI9N AI10N AI11N AI12N
+  AI13N AX0N AX1N AX2N AX3N AX4N AX5N AX6N_TERM AY0N AY1N AY2N BLTERM0_0
+  BLTERM0_1 BLTERM0_2 BLTERM0_3 BLTERM0_4 BLTERM0_5 BLTERM0_6 BLTERM0_7
+  BLTERM0_8 BLTERM0_9 BLTERM0_10 BLTERM0_11 BLTERM0_12 BLTERM0_13 BLTERM0_14
+  BLTERM0_15 BLTERM0_16 BLTERM0_17 BLTERM0_18 BLTERM0_19 BLTERM0_20
+  BLTERM0__0 BLTERM0__1 BLTERM0__2 BLTERM0__3 BLTERM0__4 BLTERM0__5
+  BLTERM0__6 BLTERM0__7 BLTERM0__8 BLTERM0__9 BLTERM0__10 BLTERM0__11
+  BLTERM0__12 BLTERM0__13 BLTERM0__14 BLTERM0__15 BLTERM0__16 BLTERM0__17
+  BLTERM0__18 BLTERM0__19 BLTERM0__20 BLTERM1_0 BLTERM1_1 BLTERM1_2 BLTERM1_3
+  BLTERM1_4 BLTERM1_5 BLTERM1_6 BLTERM1_7 BLTERM1_8 BLTERM1_9 BLTERM1_10
+  BLTERM1_11 BLTERM1_12 BLTERM1_13 BLTERM1_14 BLTERM1_15 BLTERM1_16
+  BLTERM1_17 BLTERM1_18 BLTERM1_19 BLTERM1_20 BLTERM1__0 BLTERM1__1
+  BLTERM1__2 BLTERM1__3 BLTERM1__4 BLTERM1__5 BLTERM1__6 BLTERM1__7
+  BLTERM1__8 BLTERM1__9 BLTERM1__10 BLTERM1__11 BLTERM1__12 BLTERM1__13
+  BLTERM1__14 BLTERM1__15 BLTERM1__16 BLTERM1__17 BLTERM1__18 BLTERM1__19
+  BLTERM1__20 BLTERM2_0 BLTERM2_1 BLTERM2_2 BLTERM2_3 BLTERM2_4 BLTERM2_5
+  BLTERM2_6 BLTERM2_7 BLTERM2_8 BLTERM2_9 BLTERM2_10 BLTERM2_11 BLTERM2_12
+  BLTERM2_13 BLTERM2_14 BLTERM2_15 BLTERM2_16 BLTERM2_17 BLTERM2_18
+  BLTERM2_19 BLTERM2_20 BLTERM2__0 BLTERM2__1 BLTERM2__2 BLTERM2__3
+  BLTERM2__4 BLTERM2__5 BLTERM2__6 BLTERM2__7 BLTERM2__8 BLTERM2__9
+  BLTERM2__10 BLTERM2__11 BLTERM2__12 BLTERM2__13 BLTERM2__14 BLTERM2__15
+  BLTERM2__16 BLTERM2__17 BLTERM2__18 BLTERM2__19 BLTERM2__20 BLTERM3_0
+  BLTERM3_1 BLTERM3_2 BLTERM3_3 BLTERM3_4 BLTERM3_5 BLTERM3_6 BLTERM3_7
+  BLTERM3_8 BLTERM3_9 BLTERM3_10 BLTERM3_11 BLTERM3_12 BLTERM3_13 BLTERM3_14
+  BLTERM3_15 BLTERM3_16 BLTERM3_17 BLTERM3_18 BLTERM3_19 BLTERM3_20
+  BLTERM3__0 BLTERM3__1 BLTERM3__2 BLTERM3__3 BLTERM3__4 BLTERM3__5
+  BLTERM3__6 BLTERM3__7 BLTERM3__8 BLTERM3__9 BLTERM3__10 BLTERM3__11
+  BLTERM3__12 BLTERM3__13 BLTERM3__14 BLTERM3__15 BLTERM3__16 BLTERM3__17
+  BLTERM3__18 BLTERM3__19 BLTERM3__20 BS0_TERM BS1_TERM BWEI_0 BWEI_1 BWEI_2
+  BWEI_3 BWEI_4 BWEI_5 BWEI_6 BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12
+  BWEI_13 BWEI_14 BWEI_15 BWEI_16 BWEI_17 BWEI_18 BWEI_19 BWEI_20 CEI CLK
+  CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN
+  CREN CREN CREN CREN CREN CREN DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6
+  DNI_7 DNI_8 DNI_9 DNI_10 DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 DNI_16 DNI_17
+  DNI_18 DNI_19 DNI_20 EMA0 EMA1 EMA2 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5
+  GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16
+  GDL_17 GDL_18 GDL_19 GDL_20 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5
+  GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15
+  GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GTP GTPD GTPD RET_20 RETN_TERM_20
+  LGWEN MATCH0 MATCH0 MATCH0 MATCH0 MBL TL0_TERM_1 TL0_TERM_1 MGTPS MWLLATE
+  AI12 AI12 Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9 Q__10 Q__11
+  Q__12 Q__13 Q__14 Q__15 Q__16 Q__17 Q__18 Q__19 Q__20 RDTN RETN RRENDD RXP0
+  RXP1 RXP2 RXP3 AI12 MATCH0 CREN CREN AI12 AI12 AI12 TL0_TERM_1 WBTDD WEI
+  VSSE VDDPE VDDCE icache_tag_storeBR21IO8B1
.ENDS icache_tag_storeF512X21M4B1
****
.SUBCKT icache_tag_store Q[20] Q[19] Q[18] Q[17] Q[16] Q[15] Q[14] Q[13] Q[12]
+  Q[11] Q[10] Q[9] Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] CLK CEN
+  WEN[20] WEN[19] WEN[18] WEN[17] WEN[16] WEN[15] WEN[14] WEN[13] WEN[12]
+  WEN[11] WEN[10] WEN[9] WEN[8] WEN[7] WEN[6] WEN[5] WEN[4] WEN[3] WEN[2]
+  WEN[1] WEN[0] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] D[20] D[19]
+  D[18] D[17] D[16] D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6]
+  D[5] D[4] D[3] D[2] D[1] D[0] EMA[2] EMA[1] EMA[0] GWEN RETN VSSE VDDPE
+  VDDCE
** icache_tag_store: 80338 flat devices **
XTOP A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] AI12 WEN[0] WEN[1] WEN[2]
+  WEN[3] WEN[4] WEN[5] WEN[6] WEN[7] WEN[8] WEN[9] WEN[10] WEN[11] WEN[12]
+  WEN[13] WEN[14] WEN[15] WEN[16] WEN[17] WEN[18] WEN[19] WEN[20] CEN CLK
+  CREN D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12]
+  D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] EMA[0] EMA[1] EMA[2] Q[0]
+  Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14]
+  Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] RETN GWEN VSSE VDDPE VDDCE
+  icache_tag_storeF512X21M4B1
.ENDS icache_tag_store
